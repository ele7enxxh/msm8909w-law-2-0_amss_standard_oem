tree "BB_CLK1"
  tree "BB_CLK1"
    tree "BB_CLK1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_REVISION1 (at 0x5100)"
      tindex a:0xfc4cfa00 %l 0x8051000 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_REVISION2 (at 0x5101)"
      tindex a:0xfc4cfa00 %l 0x8051010 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_REVISION3 (at 0x5102)"
      tindex a:0xfc4cfa00 %l 0x8051020 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_REVISION4 (at 0x5103)"
      tindex a:0xfc4cfa00 %l 0x8051030 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_TYPE (at 0x5104)"
      tindex a:0xfc4cfa00 %l 0x8051040 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_SUBTYPE (at 0x5105)"
      tindex a:0xfc4cfa00 %l 0x8051050 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_STATUS1 (at 0x5108)"
      tindex a:0xfc4cfa00 %l 0x8051080 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK1_EDGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_EDGE_CTL1 (at 0x5143)"
      tindex a:0xfc4cfa00 %l 0x8051430 0x51430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK1_DRV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_DRV_CTL1 (at 0x5144)"
      tindex a:0xfc4cfa00 %l 0x8051440 0x51440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_EN_CTL (at 0x5146)"
      tindex a:0xfc4cfa00 %l 0x8051460 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK1_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PD_CTL (at 0x5148)"
      tindex a:0xfc4cfa00 %l 0x8051480 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_SEC_ACCESS (at 0x51d0)"
      tindex a:0xfc4cfa00 %l 0x8051d00 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_RESET_CTL1 (at 0x51d8)"
      tindex a:0xfc4cfa00 %l 0x8051d80 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_RESET_CTL2 (at 0x51d9)"
      tindex a:0xfc4cfa00 %l 0x8051d90 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_RESET_CTL3 (at 0x51da)"
      tindex a:0xfc4cfa00 %l 0x8051da0 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BB_CLK1_PERPH_RESET_CTL4 (at 0x51db)"
      tindex a:0xfc4cfa00 %l 0x8051db0 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
      tindex a:0xfc4cfa00 %l 0x8110000 0x110000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
      tindex a:0xfc4cfa00 %l 0x8110010 0x110010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
      tindex a:0xfc4cfa00 %l 0x8110020 0x110020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
      tindex a:0xfc4cfa00 %l 0x8110030 0x110030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
      tindex a:0xfc4cfa00 %l 0x8110040 0x110040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
      tindex a:0xfc4cfa00 %l 0x8110050 0x110050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_STATUS (at 0x11008)"
      tindex a:0xfc4cfa00 %l 0x8110080 0x110080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
      tindex a:0xfc4cfa00 %l 0x8110100 0x110100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
      tindex a:0xfc4cfa00 %l 0x8110110 0x110110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
      tindex a:0xfc4cfa00 %l 0x8110120 0x110120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
      tindex a:0xfc4cfa00 %l 0x8110130 0x110130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
      tindex a:0xfc4cfa00 %l 0x8110140 0x110140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
      tindex a:0xfc4cfa00 %l 0x8110150 0x110150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
      tindex a:0xfc4cfa00 %l 0x8110160 0x110160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
      tindex a:0xfc4cfa00 %l 0x8110180 0x110180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
      tindex a:0xfc4cfa00 %l 0x8110190 0x110190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
      tindex a:0xfc4cfa00 %l 0x81101a0 0x1101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
      tindex a:0xfc4cfa00 %l 0x81101b0 0x1101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
      tindex a:0xfc4cfa00 %l 0x8110460 0x110460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
      tindex a:0xfc4cfa00 %l 0x8110500 0x110500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
      tindex a:0xfc4cfa00 %l 0x8110510 0x110510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
      tindex a:0xfc4cfa00 %l 0x8110d00 0x110d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
      tindex a:0xfc4cfa00 %l 0x8110d90 0x110d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
      tindex a:0xfc4cfa00 %l 0x8110da0 0x110da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
      tindex a:0xfc4cfa00 %l 0x8110db0 0x110db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
      tindex a:0xfc4cfa00 %l 0x8110e00 0x110e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
      tindex a:0xfc4cfa00 %l 0x8110e10 0x110e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
      tindex a:0xfc4cfa00 %l 0x8110e20 0x110e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
      tindex a:0xfc4cfa00 %l 0x8110e30 0x110e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
      tindex a:0xfc4cfa00 %l 0x8110e40 0x110e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
      tindex a:0xfc4cfa00 %l 0x8110e50 0x110e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BUA_4UICC_DUAL_BATT_ALARM"
  tree "BUA_4UICC_DUAL_BATT_ALARM"
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_REVISION1 (at 0x1c00)"
      tindex a:0xfc4cfa00 %l 0x801c000 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_REVISION2 (at 0x1c01)"
      tindex a:0xfc4cfa00 %l 0x801c010 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_REVISION3 (at 0x1c02)"
      tindex a:0xfc4cfa00 %l 0x801c020 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_REVISION4 (at 0x1c03)"
      tindex a:0xfc4cfa00 %l 0x801c030 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE (at 0x1c04)"
      tindex a:0xfc4cfa00 %l 0x801c040 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE (at 0x1c05)"
      tindex a:0xfc4cfa00 %l 0x801c050 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_STATUS1 (at 0x1c08)"
      tindex a:0xfc4cfa00 %l 0x801c080 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_STATUS2 (at 0x1c09)"
      tindex a:0xfc4cfa00 %l 0x801c090 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS (at 0x1c10)"
      tindex a:0xfc4cfa00 %l 0x801c100 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE (at 0x1c11)"
      tindex a:0xfc4cfa00 %l 0x801c110 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH (at 0x1c12)"
      tindex a:0xfc4cfa00 %l 0x801c120 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW (at 0x1c13)"
      tindex a:0xfc4cfa00 %l 0x801c130 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR (at 0x1c14)"
      tindex a:0xfc4cfa00 %l 0x801c140 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET (at 0x1c15)"
      tindex a:0xfc4cfa00 %l 0x801c150 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR (at 0x1c16)"
      tindex a:0xfc4cfa00 %l 0x801c160 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS (at 0x1c18)"
      tindex a:0xfc4cfa00 %l 0x801c180 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS (at 0x1c19)"
      tindex a:0xfc4cfa00 %l 0x801c190 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL (at 0x1c1a)"
      tindex a:0xfc4cfa00 %l 0x801c1a0 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY (at 0x1c1b)"
      tindex a:0xfc4cfa00 %l 0x801c1b0 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1 (at 0x1c40)"
      tindex a:0xfc4cfa00 %l 0x801c400 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_GONE_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1 (at 0x1c46)"
      tindex a:0xfc4cfa00 %l 0x801c460 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2 (at 0x1c47)"
      tindex a:0xfc4cfa00 %l 0x801c470 0x1c470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BAT_GONE_COMP                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS (at 0x1cd0)"
      tindex a:0xfc4cfa00 %l 0x801cd00 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1 (at 0x1cd8)"
      tindex a:0xfc4cfa00 %l 0x801cd80 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2 (at 0x1cd9)"
      tindex a:0xfc4cfa00 %l 0x801cd90 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3 (at 0x1cda)"
      tindex a:0xfc4cfa00 %l 0x801cda0 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4 (at 0x1cdb)"
      tindex a:0xfc4cfa00 %l 0x801cdb0 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1 (at 0x1ce0)"
      tindex a:0xfc4cfa00 %l 0x801ce00 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL (at 0x1ce1)"
      tindex a:0xfc4cfa00 %l 0x801ce10 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUA_4UICC_DUAL_BATT_ALARM_TEST1 (at 0x1ce2)"
      tindex a:0xfc4cfa00 %l 0x801ce20 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST_SEL2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_REVISION1 (at 0x400)"
      tindex a:0xfc4cfa00 %l 0x8004000 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_REVISION2 (at 0x401)"
      tindex a:0xfc4cfa00 %l 0x8004010 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_TYPE (at 0x404)"
      tindex a:0xfc4cfa00 %l 0x8004040 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_SUBTYPE (at 0x405)"
      tindex a:0xfc4cfa00 %l 0x8004050 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_STATUS1 (at 0x408)"
      tindex a:0xfc4cfa00 %l 0x8004080 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_TIMEOUT (at 0x444)"
      tindex a:0xfc4cfa00 %l 0x8004440 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_SEC_ACCESS (at 0x4d0)"
      tindex a:0xfc4cfa00 %l 0x8004d00 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
      tindex a:0xfc4cfa00 %l 0x8004d90 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL3 (at 0x4da)"
      tindex a:0xfc4cfa00 %l 0x8004da0 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL4 (at 0x4db)"
      tindex a:0xfc4cfa00 %l 0x8004db0 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_TEST1 (at 0x4e2)"
      tindex a:0xfc4cfa00 %l 0x8004e20 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION1 (at 0x5900)"
      tindex a:0xfc4cfa00 %l 0x8059000 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION2 (at 0x5901)"
      tindex a:0xfc4cfa00 %l 0x8059010 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION3 (at 0x5902)"
      tindex a:0xfc4cfa00 %l 0x8059020 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION4 (at 0x5903)"
      tindex a:0xfc4cfa00 %l 0x8059030 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_TYPE (at 0x5904)"
      tindex a:0xfc4cfa00 %l 0x8059040 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
      tindex a:0xfc4cfa00 %l 0x8059050 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_STATUS1 (at 0x5908)"
      tindex a:0xfc4cfa00 %l 0x8059080 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_RT_STS (at 0x5910)"
      tindex a:0xfc4cfa00 %l 0x8059100 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_SET_TYPE (at 0x5911)"
      tindex a:0xfc4cfa00 %l 0x8059110 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
      tindex a:0xfc4cfa00 %l 0x8059120 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
      tindex a:0xfc4cfa00 %l 0x8059130 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
      tindex a:0xfc4cfa00 %l 0x8059140 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_EN_SET (at 0x5915)"
      tindex a:0xfc4cfa00 %l 0x8059150 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_EN_CLR (at 0x5916)"
      tindex a:0xfc4cfa00 %l 0x8059160 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
      tindex a:0xfc4cfa00 %l 0x8059180 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_PENDING_STS (at 0x5919)"
      tindex a:0xfc4cfa00 %l 0x8059190 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_MID_SEL (at 0x591a)"
      tindex a:0xfc4cfa00 %l 0x80591a0 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_PRIORITY (at 0x591b)"
      tindex a:0xfc4cfa00 %l 0x80591b0 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL1 (at 0x5940)"
      tindex a:0xfc4cfa00 %l 0x8059400 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL2 (at 0x5941)"
      tindex a:0xfc4cfa00 %l 0x8059410 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL3 (at 0x5942)"
      tindex a:0xfc4cfa00 %l 0x8059420 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL4 (at 0x5943)"
      tindex a:0xfc4cfa00 %l 0x8059430 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_HALT_CTL (at 0x5945)"
      tindex a:0xfc4cfa00 %l 0x8059450 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RC_CTL (at 0x5946)"
      tindex a:0xfc4cfa00 %l 0x8059460 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PD_CTL (at 0x5948)"
      tindex a:0xfc4cfa00 %l 0x8059480 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
      tindex a:0xfc4cfa00 %l 0x80594a0 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_SPARE1 (at 0x5951)"
      tindex a:0xfc4cfa00 %l 0x8059510 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_SPARE2 (at 0x5952)"
      tindex a:0xfc4cfa00 %l 0x8059520 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_SPARE3 (at 0x5953)"
      tindex a:0xfc4cfa00 %l 0x8059530 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_SEC_ACCESS (at 0x59d0)"
      tindex a:0xfc4cfa00 %l 0x8059d00 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
      tindex a:0xfc4cfa00 %l 0x8059d90 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
      tindex a:0xfc4cfa00 %l 0x8059da0 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
      tindex a:0xfc4cfa00 %l 0x8059db0 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_TEST1 (at 0x59e0)"
      tindex a:0xfc4cfa00 %l 0x8059e00 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
      tindex a:0xfc4cfa00 %l 0x8059e10 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TEST1 (at 0x59e2)"
      tindex a:0xfc4cfa00 %l 0x8059e20 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TEST2 (at 0x59e4)"
      tindex a:0xfc4cfa00 %l 0x8059e40 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TRIM_NUM (at 0x59f0)"
      tindex a:0xfc4cfa00 %l 0x8059f00 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
      tindex a:0xfc4cfa00 %l 0x8059f10 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RCLF_TRIM (at 0x59f2)"
      tindex a:0xfc4cfa00 %l 0x8059f20 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_REVISION1 (at 0x5b00)"
      tindex a:0xfc4cfa00 %l 0x805b000 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_REVISION2 (at 0x5b01)"
      tindex a:0xfc4cfa00 %l 0x805b010 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
      tindex a:0xfc4cfa00 %l 0x805b040 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
      tindex a:0xfc4cfa00 %l 0x805b050 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_STATUS1 (at 0x5b08)"
      tindex a:0xfc4cfa00 %l 0x805b080 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
      tindex a:0xfc4cfa00 %l 0x805b430 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_EN_CTL (at 0x5b46)"
      tindex a:0xfc4cfa00 %l 0x805b460 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
      tindex a:0xfc4cfa00 %l 0x805bd00 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
      tindex a:0xfc4cfa00 %l 0x805bd80 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
      tindex a:0xfc4cfa00 %l 0x805bd90 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
      tindex a:0xfc4cfa00 %l 0x805bda0 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
      tindex a:0xfc4cfa00 %l 0x805bdb0 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK2"
  tree "DIV_CLK2"
    tree "DIV_CLK2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_REVISION1 (at 0x5c00)"
      tindex a:0xfc4cfa00 %l 0x805c000 0x5c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_REVISION2 (at 0x5c01)"
      tindex a:0xfc4cfa00 %l 0x805c010 0x5c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_TYPE (at 0x5c04)"
      tindex a:0xfc4cfa00 %l 0x805c040 0x5c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_SUBTYPE (at 0x5c05)"
      tindex a:0xfc4cfa00 %l 0x805c050 0x5c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_STATUS1 (at 0x5c08)"
      tindex a:0xfc4cfa00 %l 0x805c080 0x5c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK2_DIV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_DIV_CTL1 (at 0x5c43)"
      tindex a:0xfc4cfa00 %l 0x805c430 0x5c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_EN_CTL (at 0x5c46)"
      tindex a:0xfc4cfa00 %l 0x805c460 0x5c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_SEC_ACCESS (at 0x5cd0)"
      tindex a:0xfc4cfa00 %l 0x805cd00 0x5cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_RESET_CTL1 (at 0x5cd8)"
      tindex a:0xfc4cfa00 %l 0x805cd80 0x5cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_RESET_CTL2 (at 0x5cd9)"
      tindex a:0xfc4cfa00 %l 0x805cd90 0x5cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_RESET_CTL3 (at 0x5cda)"
      tindex a:0xfc4cfa00 %l 0x805cda0 0x5cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK2_PERPH_RESET_CTL4 (at 0x5cdb)"
      tindex a:0xfc4cfa00 %l 0x805cdb0 0x5cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK3"
  tree "DIV_CLK3"
    tree "DIV_CLK3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_REVISION1 (at 0x5d00)"
      tindex a:0xfc4cfa00 %l 0x805d000 0x5d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_REVISION2 (at 0x5d01)"
      tindex a:0xfc4cfa00 %l 0x805d010 0x5d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_TYPE (at 0x5d04)"
      tindex a:0xfc4cfa00 %l 0x805d040 0x5d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_SUBTYPE (at 0x5d05)"
      tindex a:0xfc4cfa00 %l 0x805d050 0x5d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_STATUS1 (at 0x5d08)"
      tindex a:0xfc4cfa00 %l 0x805d080 0x5d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK3_DIV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_DIV_CTL1 (at 0x5d43)"
      tindex a:0xfc4cfa00 %l 0x805d430 0x5d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_EN_CTL (at 0x5d46)"
      tindex a:0xfc4cfa00 %l 0x805d460 0x5d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_SEC_ACCESS (at 0x5dd0)"
      tindex a:0xfc4cfa00 %l 0x805dd00 0x5dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_RESET_CTL1 (at 0x5dd8)"
      tindex a:0xfc4cfa00 %l 0x805dd80 0x5dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_RESET_CTL2 (at 0x5dd9)"
      tindex a:0xfc4cfa00 %l 0x805dd90 0x5dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_RESET_CTL3 (at 0x5dda)"
      tindex a:0xfc4cfa00 %l 0x805dda0 0x5dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "DIV_CLK3_PERPH_RESET_CTL4 (at 0x5ddb)"
      tindex a:0xfc4cfa00 %l 0x805ddb0 0x5ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_REVISION1 (at 0xc000)"
      tindex a:0xfc4cfa00 %l 0x80c0000 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_REVISION2 (at 0xc001)"
      tindex a:0xfc4cfa00 %l 0x80c0010 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_REVISION3 (at 0xc002)"
      tindex a:0xfc4cfa00 %l 0x80c0020 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_REVISION4 (at 0xc003)"
      tindex a:0xfc4cfa00 %l 0x80c0030 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_TYPE (at 0xc004)"
      tindex a:0xfc4cfa00 %l 0x80c0040 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_SUBTYPE (at 0xc005)"
      tindex a:0xfc4cfa00 %l 0x80c0050 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_STATUS1 (at 0xc008)"
      tindex a:0xfc4cfa00 %l 0x80c0080 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_RT_STS (at 0xc010)"
      tindex a:0xfc4cfa00 %l 0x80c0100 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_SET_TYPE (at 0xc011)"
      tindex a:0xfc4cfa00 %l 0x80c0110 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
      tindex a:0xfc4cfa00 %l 0x80c0120 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_POLARITY_LOW (at 0xc013)"
      tindex a:0xfc4cfa00 %l 0x80c0130 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_LATCHED_CLR (at 0xc014)"
      tindex a:0xfc4cfa00 %l 0x80c0140 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_EN_SET (at 0xc015)"
      tindex a:0xfc4cfa00 %l 0x80c0150 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_EN_CLR (at 0xc016)"
      tindex a:0xfc4cfa00 %l 0x80c0160 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_LATCHED_STS (at 0xc018)"
      tindex a:0xfc4cfa00 %l 0x80c0180 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_PENDING_STS (at 0xc019)"
      tindex a:0xfc4cfa00 %l 0x80c0190 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_MID_SEL (at 0xc01a)"
      tindex a:0xfc4cfa00 %l 0x80c01a0 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_INT_PRIORITY (at 0xc01b)"
      tindex a:0xfc4cfa00 %l 0x80c01b0 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_MODE_CTL (at 0xc040)"
      tindex a:0xfc4cfa00 %l 0x80c0400 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_DIG_VIN_CTL (at 0xc041)"
      tindex a:0xfc4cfa00 %l 0x80c0410 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_DIG_PULL_CTL (at 0xc042)"
      tindex a:0xfc4cfa00 %l 0x80c0420 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_DIG_IN_CTL (at 0xc043)"
      tindex a:0xfc4cfa00 %l 0x80c0430 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_DIG_OUT_CTL (at 0xc045)"
      tindex a:0xfc4cfa00 %l 0x80c0450 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_EN_CTL (at 0xc046)"
      tindex a:0xfc4cfa00 %l 0x80c0460 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_SEC_ACCESS (at 0xc0d0)"
      tindex a:0xfc4cfa00 %l 0x80c0d00 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
      tindex a:0xfc4cfa00 %l 0x80c0d80 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
      tindex a:0xfc4cfa00 %l 0x80c0d90 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
      tindex a:0xfc4cfa00 %l 0x80c0da0 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
      tindex a:0xfc4cfa00 %l 0x80c0db0 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_REVISION1 (at 0xc100)"
      tindex a:0xfc4cfa00 %l 0x80c1000 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_REVISION2 (at 0xc101)"
      tindex a:0xfc4cfa00 %l 0x80c1010 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_REVISION3 (at 0xc102)"
      tindex a:0xfc4cfa00 %l 0x80c1020 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_REVISION4 (at 0xc103)"
      tindex a:0xfc4cfa00 %l 0x80c1030 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_TYPE (at 0xc104)"
      tindex a:0xfc4cfa00 %l 0x80c1040 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_SUBTYPE (at 0xc105)"
      tindex a:0xfc4cfa00 %l 0x80c1050 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_STATUS1 (at 0xc108)"
      tindex a:0xfc4cfa00 %l 0x80c1080 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_RT_STS (at 0xc110)"
      tindex a:0xfc4cfa00 %l 0x80c1100 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_SET_TYPE (at 0xc111)"
      tindex a:0xfc4cfa00 %l 0x80c1110 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
      tindex a:0xfc4cfa00 %l 0x80c1120 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_POLARITY_LOW (at 0xc113)"
      tindex a:0xfc4cfa00 %l 0x80c1130 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_LATCHED_CLR (at 0xc114)"
      tindex a:0xfc4cfa00 %l 0x80c1140 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_EN_SET (at 0xc115)"
      tindex a:0xfc4cfa00 %l 0x80c1150 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_EN_CLR (at 0xc116)"
      tindex a:0xfc4cfa00 %l 0x80c1160 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_LATCHED_STS (at 0xc118)"
      tindex a:0xfc4cfa00 %l 0x80c1180 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_PENDING_STS (at 0xc119)"
      tindex a:0xfc4cfa00 %l 0x80c1190 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_MID_SEL (at 0xc11a)"
      tindex a:0xfc4cfa00 %l 0x80c11a0 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_INT_PRIORITY (at 0xc11b)"
      tindex a:0xfc4cfa00 %l 0x80c11b0 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_MODE_CTL (at 0xc140)"
      tindex a:0xfc4cfa00 %l 0x80c1400 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_DIG_VIN_CTL (at 0xc141)"
      tindex a:0xfc4cfa00 %l 0x80c1410 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_DIG_PULL_CTL (at 0xc142)"
      tindex a:0xfc4cfa00 %l 0x80c1420 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_DIG_IN_CTL (at 0xc143)"
      tindex a:0xfc4cfa00 %l 0x80c1430 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_DIG_OUT_CTL (at 0xc145)"
      tindex a:0xfc4cfa00 %l 0x80c1450 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_EN_CTL (at 0xc146)"
      tindex a:0xfc4cfa00 %l 0x80c1460 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_SEC_ACCESS (at 0xc1d0)"
      tindex a:0xfc4cfa00 %l 0x80c1d00 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
      tindex a:0xfc4cfa00 %l 0x80c1d80 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
      tindex a:0xfc4cfa00 %l 0x80c1d90 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
      tindex a:0xfc4cfa00 %l 0x80c1da0 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
      tindex a:0xfc4cfa00 %l 0x80c1db0 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_REVISION1 (at 0xc200)"
      tindex a:0xfc4cfa00 %l 0x80c2000 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_REVISION2 (at 0xc201)"
      tindex a:0xfc4cfa00 %l 0x80c2010 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_REVISION3 (at 0xc202)"
      tindex a:0xfc4cfa00 %l 0x80c2020 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_REVISION4 (at 0xc203)"
      tindex a:0xfc4cfa00 %l 0x80c2030 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_TYPE (at 0xc204)"
      tindex a:0xfc4cfa00 %l 0x80c2040 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_SUBTYPE (at 0xc205)"
      tindex a:0xfc4cfa00 %l 0x80c2050 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_STATUS1 (at 0xc208)"
      tindex a:0xfc4cfa00 %l 0x80c2080 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_RT_STS (at 0xc210)"
      tindex a:0xfc4cfa00 %l 0x80c2100 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_SET_TYPE (at 0xc211)"
      tindex a:0xfc4cfa00 %l 0x80c2110 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
      tindex a:0xfc4cfa00 %l 0x80c2120 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_POLARITY_LOW (at 0xc213)"
      tindex a:0xfc4cfa00 %l 0x80c2130 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_LATCHED_CLR (at 0xc214)"
      tindex a:0xfc4cfa00 %l 0x80c2140 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_EN_SET (at 0xc215)"
      tindex a:0xfc4cfa00 %l 0x80c2150 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_EN_CLR (at 0xc216)"
      tindex a:0xfc4cfa00 %l 0x80c2160 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_LATCHED_STS (at 0xc218)"
      tindex a:0xfc4cfa00 %l 0x80c2180 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_PENDING_STS (at 0xc219)"
      tindex a:0xfc4cfa00 %l 0x80c2190 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_MID_SEL (at 0xc21a)"
      tindex a:0xfc4cfa00 %l 0x80c21a0 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_INT_PRIORITY (at 0xc21b)"
      tindex a:0xfc4cfa00 %l 0x80c21b0 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_MODE_CTL (at 0xc240)"
      tindex a:0xfc4cfa00 %l 0x80c2400 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_DIG_VIN_CTL (at 0xc241)"
      tindex a:0xfc4cfa00 %l 0x80c2410 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_DIG_PULL_CTL (at 0xc242)"
      tindex a:0xfc4cfa00 %l 0x80c2420 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_DIG_IN_CTL (at 0xc243)"
      tindex a:0xfc4cfa00 %l 0x80c2430 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_DIG_OUT_CTL (at 0xc245)"
      tindex a:0xfc4cfa00 %l 0x80c2450 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_EN_CTL (at 0xc246)"
      tindex a:0xfc4cfa00 %l 0x80c2460 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_SEC_ACCESS (at 0xc2d0)"
      tindex a:0xfc4cfa00 %l 0x80c2d00 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
      tindex a:0xfc4cfa00 %l 0x80c2d80 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
      tindex a:0xfc4cfa00 %l 0x80c2d90 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
      tindex a:0xfc4cfa00 %l 0x80c2da0 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
      tindex a:0xfc4cfa00 %l 0x80c2db0 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_REVISION1 (at 0xc300)"
      tindex a:0xfc4cfa00 %l 0x80c3000 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_REVISION2 (at 0xc301)"
      tindex a:0xfc4cfa00 %l 0x80c3010 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_REVISION3 (at 0xc302)"
      tindex a:0xfc4cfa00 %l 0x80c3020 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_REVISION4 (at 0xc303)"
      tindex a:0xfc4cfa00 %l 0x80c3030 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_TYPE (at 0xc304)"
      tindex a:0xfc4cfa00 %l 0x80c3040 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_SUBTYPE (at 0xc305)"
      tindex a:0xfc4cfa00 %l 0x80c3050 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_STATUS1 (at 0xc308)"
      tindex a:0xfc4cfa00 %l 0x80c3080 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_RT_STS (at 0xc310)"
      tindex a:0xfc4cfa00 %l 0x80c3100 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_SET_TYPE (at 0xc311)"
      tindex a:0xfc4cfa00 %l 0x80c3110 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
      tindex a:0xfc4cfa00 %l 0x80c3120 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_POLARITY_LOW (at 0xc313)"
      tindex a:0xfc4cfa00 %l 0x80c3130 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_LATCHED_CLR (at 0xc314)"
      tindex a:0xfc4cfa00 %l 0x80c3140 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_EN_SET (at 0xc315)"
      tindex a:0xfc4cfa00 %l 0x80c3150 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_EN_CLR (at 0xc316)"
      tindex a:0xfc4cfa00 %l 0x80c3160 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_LATCHED_STS (at 0xc318)"
      tindex a:0xfc4cfa00 %l 0x80c3180 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_PENDING_STS (at 0xc319)"
      tindex a:0xfc4cfa00 %l 0x80c3190 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_MID_SEL (at 0xc31a)"
      tindex a:0xfc4cfa00 %l 0x80c31a0 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_INT_PRIORITY (at 0xc31b)"
      tindex a:0xfc4cfa00 %l 0x80c31b0 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_MODE_CTL (at 0xc340)"
      tindex a:0xfc4cfa00 %l 0x80c3400 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_DIG_VIN_CTL (at 0xc341)"
      tindex a:0xfc4cfa00 %l 0x80c3410 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_DIG_PULL_CTL (at 0xc342)"
      tindex a:0xfc4cfa00 %l 0x80c3420 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_DIG_IN_CTL (at 0xc343)"
      tindex a:0xfc4cfa00 %l 0x80c3430 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_DIG_OUT_CTL (at 0xc345)"
      tindex a:0xfc4cfa00 %l 0x80c3450 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_EN_CTL (at 0xc346)"
      tindex a:0xfc4cfa00 %l 0x80c3460 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_SEC_ACCESS (at 0xc3d0)"
      tindex a:0xfc4cfa00 %l 0x80c3d00 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
      tindex a:0xfc4cfa00 %l 0x80c3d80 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
      tindex a:0xfc4cfa00 %l 0x80c3d90 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
      tindex a:0xfc4cfa00 %l 0x80c3da0 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
      tindex a:0xfc4cfa00 %l 0x80c3db0 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO5"
  tree "GPIO5"
    tree "GPIO5_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_REVISION1 (at 0xc400)"
      tindex a:0xfc4cfa00 %l 0x80c4000 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_REVISION2 (at 0xc401)"
      tindex a:0xfc4cfa00 %l 0x80c4010 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO5_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_REVISION3 (at 0xc402)"
      tindex a:0xfc4cfa00 %l 0x80c4020 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_REVISION4 (at 0xc403)"
      tindex a:0xfc4cfa00 %l 0x80c4030 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO5_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_TYPE (at 0xc404)"
      tindex a:0xfc4cfa00 %l 0x80c4040 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO5_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_SUBTYPE (at 0xc405)"
      tindex a:0xfc4cfa00 %l 0x80c4050 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO5_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_STATUS1 (at 0xc408)"
      tindex a:0xfc4cfa00 %l 0x80c4080 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO5_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_RT_STS (at 0xc410)"
      tindex a:0xfc4cfa00 %l 0x80c4100 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO5_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_SET_TYPE (at 0xc411)"
      tindex a:0xfc4cfa00 %l 0x80c4110 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO5_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_POLARITY_HIGH (at 0xc412)"
      tindex a:0xfc4cfa00 %l 0x80c4120 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_POLARITY_LOW (at 0xc413)"
      tindex a:0xfc4cfa00 %l 0x80c4130 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_LATCHED_CLR (at 0xc414)"
      tindex a:0xfc4cfa00 %l 0x80c4140 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_EN_SET (at 0xc415)"
      tindex a:0xfc4cfa00 %l 0x80c4150 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_EN_CLR (at 0xc416)"
      tindex a:0xfc4cfa00 %l 0x80c4160 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_LATCHED_STS (at 0xc418)"
      tindex a:0xfc4cfa00 %l 0x80c4180 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO5_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_PENDING_STS (at 0xc419)"
      tindex a:0xfc4cfa00 %l 0x80c4190 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO5_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_MID_SEL (at 0xc41a)"
      tindex a:0xfc4cfa00 %l 0x80c41a0 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO5_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_INT_PRIORITY (at 0xc41b)"
      tindex a:0xfc4cfa00 %l 0x80c41b0 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO5_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_MODE_CTL (at 0xc440)"
      tindex a:0xfc4cfa00 %l 0x80c4400 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO5_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_DIG_VIN_CTL (at 0xc441)"
      tindex a:0xfc4cfa00 %l 0x80c4410 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO5_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_DIG_PULL_CTL (at 0xc442)"
      tindex a:0xfc4cfa00 %l 0x80c4420 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO5_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_DIG_IN_CTL (at 0xc443)"
      tindex a:0xfc4cfa00 %l 0x80c4430 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO5_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_DIG_OUT_CTL (at 0xc445)"
      tindex a:0xfc4cfa00 %l 0x80c4450 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO5_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_EN_CTL (at 0xc446)"
      tindex a:0xfc4cfa00 %l 0x80c4460 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO5_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_SEC_ACCESS (at 0xc4d0)"
      tindex a:0xfc4cfa00 %l 0x80c4d00 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO5_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_RESET_CTL1 (at 0xc4d8)"
      tindex a:0xfc4cfa00 %l 0x80c4d80 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_RESET_CTL2 (at 0xc4d9)"
      tindex a:0xfc4cfa00 %l 0x80c4d90 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_RESET_CTL3 (at 0xc4da)"
      tindex a:0xfc4cfa00 %l 0x80c4da0 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO5_PERPH_RESET_CTL4 (at 0xc4db)"
      tindex a:0xfc4cfa00 %l 0x80c4db0 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO6"
  tree "GPIO6"
    tree "GPIO6_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_REVISION1 (at 0xc500)"
      tindex a:0xfc4cfa00 %l 0x80c5000 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_REVISION2 (at 0xc501)"
      tindex a:0xfc4cfa00 %l 0x80c5010 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO6_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_REVISION3 (at 0xc502)"
      tindex a:0xfc4cfa00 %l 0x80c5020 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_REVISION4 (at 0xc503)"
      tindex a:0xfc4cfa00 %l 0x80c5030 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO6_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_TYPE (at 0xc504)"
      tindex a:0xfc4cfa00 %l 0x80c5040 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO6_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_SUBTYPE (at 0xc505)"
      tindex a:0xfc4cfa00 %l 0x80c5050 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO6_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_STATUS1 (at 0xc508)"
      tindex a:0xfc4cfa00 %l 0x80c5080 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO6_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_RT_STS (at 0xc510)"
      tindex a:0xfc4cfa00 %l 0x80c5100 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO6_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_SET_TYPE (at 0xc511)"
      tindex a:0xfc4cfa00 %l 0x80c5110 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO6_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_POLARITY_HIGH (at 0xc512)"
      tindex a:0xfc4cfa00 %l 0x80c5120 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_POLARITY_LOW (at 0xc513)"
      tindex a:0xfc4cfa00 %l 0x80c5130 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_LATCHED_CLR (at 0xc514)"
      tindex a:0xfc4cfa00 %l 0x80c5140 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_EN_SET (at 0xc515)"
      tindex a:0xfc4cfa00 %l 0x80c5150 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_EN_CLR (at 0xc516)"
      tindex a:0xfc4cfa00 %l 0x80c5160 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_LATCHED_STS (at 0xc518)"
      tindex a:0xfc4cfa00 %l 0x80c5180 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO6_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_PENDING_STS (at 0xc519)"
      tindex a:0xfc4cfa00 %l 0x80c5190 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO6_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_MID_SEL (at 0xc51a)"
      tindex a:0xfc4cfa00 %l 0x80c51a0 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO6_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_INT_PRIORITY (at 0xc51b)"
      tindex a:0xfc4cfa00 %l 0x80c51b0 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO6_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_MODE_CTL (at 0xc540)"
      tindex a:0xfc4cfa00 %l 0x80c5400 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO6_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_DIG_VIN_CTL (at 0xc541)"
      tindex a:0xfc4cfa00 %l 0x80c5410 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO6_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_DIG_PULL_CTL (at 0xc542)"
      tindex a:0xfc4cfa00 %l 0x80c5420 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO6_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_DIG_IN_CTL (at 0xc543)"
      tindex a:0xfc4cfa00 %l 0x80c5430 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO6_DIG_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_DIG_OUT_CTL (at 0xc545)"
      tindex a:0xfc4cfa00 %l 0x80c5450 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO6_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_EN_CTL (at 0xc546)"
      tindex a:0xfc4cfa00 %l 0x80c5460 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO6_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_SEC_ACCESS (at 0xc5d0)"
      tindex a:0xfc4cfa00 %l 0x80c5d00 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO6_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_RESET_CTL1 (at 0xc5d8)"
      tindex a:0xfc4cfa00 %l 0x80c5d80 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_RESET_CTL2 (at 0xc5d9)"
      tindex a:0xfc4cfa00 %l 0x80c5d90 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_RESET_CTL3 (at 0xc5da)"
      tindex a:0xfc4cfa00 %l 0x80c5da0 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "GPIO6_PERPH_RESET_CTL4 (at 0xc5db)"
      tindex a:0xfc4cfa00 %l 0x80c5db0 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_REVISION1 (at 0x500)"
      tindex a:0xfc4cfa00 %l 0x8005000 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_REVISION2 (at 0x501)"
      tindex a:0xfc4cfa00 %l 0x8005010 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_TYPE (at 0x504)"
      tindex a:0xfc4cfa00 %l 0x8005040 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_SUBTYPE (at 0x505)"
      tindex a:0xfc4cfa00 %l 0x8005050 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_STATUS1 (at 0x508)"
      tindex a:0xfc4cfa00 %l 0x8005080 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_STATUS2 (at 0x509)"
      tindex a:0xfc4cfa00 %l 0x8005090 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_INT_RESEND_ALL (at 0x540)"
      tindex a:0xfc4cfa00 %l 0x8005400 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_EN_CTL1 (at 0x546)"
      tindex a:0xfc4cfa00 %l 0x8005460 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_SEC_ACCESS (at 0x5d0)"
      tindex a:0xfc4cfa00 %l 0x8005d00 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL1 (at 0x5d8)"
      tindex a:0xfc4cfa00 %l 0x8005d80 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL2 (at 0x5d9)"
      tindex a:0xfc4cfa00 %l 0x8005d90 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL3 (at 0x5da)"
      tindex a:0xfc4cfa00 %l 0x8005da0 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL4 (at 0x5db)"
      tindex a:0xfc4cfa00 %l 0x8005db0 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_TEST1 (at 0x5e0)"
      tindex a:0xfc4cfa00 %l 0x8005e00 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_REVISION1 (at 0x14000)"
      tindex a:0xfc4cfa00 %l 0x8140000 0x140000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_REVISION2 (at 0x14001)"
      tindex a:0xfc4cfa00 %l 0x8140010 0x140010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_REVISION3 (at 0x14002)"
      tindex a:0xfc4cfa00 %l 0x8140020 0x140020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_REVISION4 (at 0x14003)"
      tindex a:0xfc4cfa00 %l 0x8140030 0x140030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_TYPE (at 0x14004)"
      tindex a:0xfc4cfa00 %l 0x8140040 0x140040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_SUBTYPE (at 0x14005)"
      tindex a:0xfc4cfa00 %l 0x8140050 0x140050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_STATUS1 (at 0x14008)"
      tindex a:0xfc4cfa00 %l 0x8140080 0x140080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO1_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_STATUS2 (at 0x14009)"
      tindex a:0xfc4cfa00 %l 0x8140090 0x140090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_STATUS3 (at 0x1400a)"
      tindex a:0xfc4cfa00 %l 0x81400a0 0x1400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_RT_STS (at 0x14010)"
      tindex a:0xfc4cfa00 %l 0x8140100 0x140100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_SET_TYPE (at 0x14011)"
      tindex a:0xfc4cfa00 %l 0x8140110 0x140110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_POLARITY_HIGH (at 0x14012)"
      tindex a:0xfc4cfa00 %l 0x8140120 0x140120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_POLARITY_LOW (at 0x14013)"
      tindex a:0xfc4cfa00 %l 0x8140130 0x140130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_LATCHED_CLR (at 0x14014)"
      tindex a:0xfc4cfa00 %l 0x8140140 0x140140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_EN_SET (at 0x14015)"
      tindex a:0xfc4cfa00 %l 0x8140150 0x140150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_EN_CLR (at 0x14016)"
      tindex a:0xfc4cfa00 %l 0x8140160 0x140160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_LATCHED_STS (at 0x14018)"
      tindex a:0xfc4cfa00 %l 0x8140180 0x140180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_PENDING_STS (at 0x14019)"
      tindex a:0xfc4cfa00 %l 0x8140190 0x140190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_MID_SEL (at 0x1401a)"
      tindex a:0xfc4cfa00 %l 0x81401a0 0x1401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_PRIORITY (at 0x1401b)"
      tindex a:0xfc4cfa00 %l 0x81401b0 0x1401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_VOLTAGE_CTL1 (at 0x14040)"
      tindex a:0xfc4cfa00 %l 0x8140400 0x140400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_VOLTAGE_CTL2 (at 0x14041)"
      tindex a:0xfc4cfa00 %l 0x8140410 0x140410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_MODE_CTL2 (at 0x14045)"
      tindex a:0xfc4cfa00 %l 0x8140450 0x140450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_EN_CTL (at 0x14046)"
      tindex a:0xfc4cfa00 %l 0x8140460 0x140460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PD_CTL (at 0x14048)"
      tindex a:0xfc4cfa00 %l 0x8140480 0x140480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
      tindex a:0xfc4cfa00 %l 0x81404a0 0x1404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_SOFT_START_CTL (at 0x1404c)"
      tindex a:0xfc4cfa00 %l 0x81404c0 0x1404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_CONFIG_CTL (at 0x14052)"
      tindex a:0xfc4cfa00 %l 0x8140520 0x140520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
      tindex a:0xfc4cfa00 %l 0x8140680 0x140680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
      tindex a:0xfc4cfa00 %l 0x8140690 0x140690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
      tindex a:0xfc4cfa00 %l 0x81406a0 0x1406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
      tindex a:0xfc4cfa00 %l 0x81406b0 0x1406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_SEC_ACCESS (at 0x140d0)"
      tindex a:0xfc4cfa00 %l 0x8140d00 0x140d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
      tindex a:0xfc4cfa00 %l 0x8140d80 0x140d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
      tindex a:0xfc4cfa00 %l 0x8140d90 0x140d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
      tindex a:0xfc4cfa00 %l 0x8140da0 0x140da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
      tindex a:0xfc4cfa00 %l 0x8140db0 0x140db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_TEST1 (at 0x140e0)"
      tindex a:0xfc4cfa00 %l 0x8140e00 0x140e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_INT_TEST_VAL (at 0x140e1)"
      tindex a:0xfc4cfa00 %l 0x8140e10 0x140e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_TEST1 (at 0x140e2)"
      tindex a:0xfc4cfa00 %l 0x8140e20 0x140e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_TEST2 (at 0x140e3)"
      tindex a:0xfc4cfa00 %l 0x8140e30 0x140e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_TRIM_NUM (at 0x140f0)"
      tindex a:0xfc4cfa00 %l 0x8140f00 0x140f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO1_TRIM_CTRL (at 0x140f1)"
      tindex a:0xfc4cfa00 %l 0x8140f10 0x140f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_REVISION1 (at 0x14900)"
      tindex a:0xfc4cfa00 %l 0x8149000 0x149000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_REVISION2 (at 0x14901)"
      tindex a:0xfc4cfa00 %l 0x8149010 0x149010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_REVISION3 (at 0x14902)"
      tindex a:0xfc4cfa00 %l 0x8149020 0x149020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_REVISION4 (at 0x14903)"
      tindex a:0xfc4cfa00 %l 0x8149030 0x149030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_TYPE (at 0x14904)"
      tindex a:0xfc4cfa00 %l 0x8149040 0x149040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_SUBTYPE (at 0x14905)"
      tindex a:0xfc4cfa00 %l 0x8149050 0x149050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_STATUS1 (at 0x14908)"
      tindex a:0xfc4cfa00 %l 0x8149080 0x149080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO10_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_STATUS2 (at 0x14909)"
      tindex a:0xfc4cfa00 %l 0x8149090 0x149090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO10_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_STATUS3 (at 0x1490a)"
      tindex a:0xfc4cfa00 %l 0x81490a0 0x1490a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO10_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_RT_STS (at 0x14910)"
      tindex a:0xfc4cfa00 %l 0x8149100 0x149100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_SET_TYPE (at 0x14911)"
      tindex a:0xfc4cfa00 %l 0x8149110 0x149110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_POLARITY_HIGH (at 0x14912)"
      tindex a:0xfc4cfa00 %l 0x8149120 0x149120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_POLARITY_LOW (at 0x14913)"
      tindex a:0xfc4cfa00 %l 0x8149130 0x149130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_LATCHED_CLR (at 0x14914)"
      tindex a:0xfc4cfa00 %l 0x8149140 0x149140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO10_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_EN_SET (at 0x14915)"
      tindex a:0xfc4cfa00 %l 0x8149150 0x149150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_EN_CLR (at 0x14916)"
      tindex a:0xfc4cfa00 %l 0x8149160 0x149160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_LATCHED_STS (at 0x14918)"
      tindex a:0xfc4cfa00 %l 0x8149180 0x149180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_PENDING_STS (at 0x14919)"
      tindex a:0xfc4cfa00 %l 0x8149190 0x149190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_MID_SEL (at 0x1491a)"
      tindex a:0xfc4cfa00 %l 0x81491a0 0x1491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO10_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_PRIORITY (at 0x1491b)"
      tindex a:0xfc4cfa00 %l 0x81491b0 0x1491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO10_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_VOLTAGE_CTL1 (at 0x14940)"
      tindex a:0xfc4cfa00 %l 0x8149400 0x149400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_VOLTAGE_CTL2 (at 0x14941)"
      tindex a:0xfc4cfa00 %l 0x8149410 0x149410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO10_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_MODE_CTL2 (at 0x14945)"
      tindex a:0xfc4cfa00 %l 0x8149450 0x149450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_EN_CTL (at 0x14946)"
      tindex a:0xfc4cfa00 %l 0x8149460 0x149460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PD_CTL (at 0x14948)"
      tindex a:0xfc4cfa00 %l 0x8149480 0x149480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO10_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_CURRENT_LIM_CTL (at 0x1494a)"
      tindex a:0xfc4cfa00 %l 0x81494a0 0x1494a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO10_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_SOFT_START_CTL (at 0x1494c)"
      tindex a:0xfc4cfa00 %l 0x81494c0 0x1494c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO10_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_CONFIG_CTL (at 0x14952)"
      tindex a:0xfc4cfa00 %l 0x8149520 0x149520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_LL_VOLTAGE_CTL1 (at 0x14968)"
      tindex a:0xfc4cfa00 %l 0x8149680 0x149680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_LL_VOLTAGE_CTL2 (at 0x14969)"
      tindex a:0xfc4cfa00 %l 0x8149690 0x149690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_UL_VOLTAGE_CTL1 (at 0x1496a)"
      tindex a:0xfc4cfa00 %l 0x81496a0 0x1496a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_UL_VOLTAGE_CTL2 (at 0x1496b)"
      tindex a:0xfc4cfa00 %l 0x81496b0 0x1496b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO10_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_SEC_ACCESS (at 0x149d0)"
      tindex a:0xfc4cfa00 %l 0x8149d00 0x149d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
      tindex a:0xfc4cfa00 %l 0x8149d80 0x149d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
      tindex a:0xfc4cfa00 %l 0x8149d90 0x149d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
      tindex a:0xfc4cfa00 %l 0x8149da0 0x149da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
      tindex a:0xfc4cfa00 %l 0x8149db0 0x149db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO10_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_TEST1 (at 0x149e0)"
      tindex a:0xfc4cfa00 %l 0x8149e00 0x149e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_INT_TEST_VAL (at 0x149e1)"
      tindex a:0xfc4cfa00 %l 0x8149e10 0x149e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO10_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_TEST1 (at 0x149e2)"
      tindex a:0xfc4cfa00 %l 0x8149e20 0x149e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_TEST2 (at 0x149e3)"
      tindex a:0xfc4cfa00 %l 0x8149e30 0x149e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO10_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_TRIM_NUM (at 0x149f0)"
      tindex a:0xfc4cfa00 %l 0x8149f00 0x149f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO10_TRIM_CTRL (at 0x149f1)"
      tindex a:0xfc4cfa00 %l 0x8149f10 0x149f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_REVISION1 (at 0x14a00)"
      tindex a:0xfc4cfa00 %l 0x814a000 0x14a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_REVISION2 (at 0x14a01)"
      tindex a:0xfc4cfa00 %l 0x814a010 0x14a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_REVISION3 (at 0x14a02)"
      tindex a:0xfc4cfa00 %l 0x814a020 0x14a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_REVISION4 (at 0x14a03)"
      tindex a:0xfc4cfa00 %l 0x814a030 0x14a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_TYPE (at 0x14a04)"
      tindex a:0xfc4cfa00 %l 0x814a040 0x14a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_SUBTYPE (at 0x14a05)"
      tindex a:0xfc4cfa00 %l 0x814a050 0x14a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_STATUS1 (at 0x14a08)"
      tindex a:0xfc4cfa00 %l 0x814a080 0x14a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO11_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_STATUS2 (at 0x14a09)"
      tindex a:0xfc4cfa00 %l 0x814a090 0x14a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO11_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_STATUS3 (at 0x14a0a)"
      tindex a:0xfc4cfa00 %l 0x814a0a0 0x14a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO11_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_RT_STS (at 0x14a10)"
      tindex a:0xfc4cfa00 %l 0x814a100 0x14a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_SET_TYPE (at 0x14a11)"
      tindex a:0xfc4cfa00 %l 0x814a110 0x14a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_POLARITY_HIGH (at 0x14a12)"
      tindex a:0xfc4cfa00 %l 0x814a120 0x14a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_POLARITY_LOW (at 0x14a13)"
      tindex a:0xfc4cfa00 %l 0x814a130 0x14a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO11_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_LATCHED_CLR (at 0x14a14)"
      tindex a:0xfc4cfa00 %l 0x814a140 0x14a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO11_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_EN_SET (at 0x14a15)"
      tindex a:0xfc4cfa00 %l 0x814a150 0x14a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_EN_CLR (at 0x14a16)"
      tindex a:0xfc4cfa00 %l 0x814a160 0x14a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_LATCHED_STS (at 0x14a18)"
      tindex a:0xfc4cfa00 %l 0x814a180 0x14a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO11_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_PENDING_STS (at 0x14a19)"
      tindex a:0xfc4cfa00 %l 0x814a190 0x14a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_MID_SEL (at 0x14a1a)"
      tindex a:0xfc4cfa00 %l 0x814a1a0 0x14a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO11_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_PRIORITY (at 0x14a1b)"
      tindex a:0xfc4cfa00 %l 0x814a1b0 0x14a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO11_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_VOLTAGE_CTL1 (at 0x14a40)"
      tindex a:0xfc4cfa00 %l 0x814a400 0x14a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_VOLTAGE_CTL2 (at 0x14a41)"
      tindex a:0xfc4cfa00 %l 0x814a410 0x14a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO11_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_MODE_CTL2 (at 0x14a45)"
      tindex a:0xfc4cfa00 %l 0x814a450 0x14a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_EN_CTL (at 0x14a46)"
      tindex a:0xfc4cfa00 %l 0x814a460 0x14a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PD_CTL (at 0x14a48)"
      tindex a:0xfc4cfa00 %l 0x814a480 0x14a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO11_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_CURRENT_LIM_CTL (at 0x14a4a)"
      tindex a:0xfc4cfa00 %l 0x814a4a0 0x14a4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO11_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_SOFT_START_CTL (at 0x14a4c)"
      tindex a:0xfc4cfa00 %l 0x814a4c0 0x14a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO11_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_CONFIG_CTL (at 0x14a52)"
      tindex a:0xfc4cfa00 %l 0x814a520 0x14a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_LL_VOLTAGE_CTL1 (at 0x14a68)"
      tindex a:0xfc4cfa00 %l 0x814a680 0x14a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_LL_VOLTAGE_CTL2 (at 0x14a69)"
      tindex a:0xfc4cfa00 %l 0x814a690 0x14a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_UL_VOLTAGE_CTL1 (at 0x14a6a)"
      tindex a:0xfc4cfa00 %l 0x814a6a0 0x14a6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_UL_VOLTAGE_CTL2 (at 0x14a6b)"
      tindex a:0xfc4cfa00 %l 0x814a6b0 0x14a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO11_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_SEC_ACCESS (at 0x14ad0)"
      tindex a:0xfc4cfa00 %l 0x814ad00 0x14ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
      tindex a:0xfc4cfa00 %l 0x814ad80 0x14ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
      tindex a:0xfc4cfa00 %l 0x814ad90 0x14ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
      tindex a:0xfc4cfa00 %l 0x814ada0 0x14ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
      tindex a:0xfc4cfa00 %l 0x814adb0 0x14adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO11_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_TEST1 (at 0x14ae0)"
      tindex a:0xfc4cfa00 %l 0x814ae00 0x14ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO11_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_INT_TEST_VAL (at 0x14ae1)"
      tindex a:0xfc4cfa00 %l 0x814ae10 0x14ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO11_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_TEST1 (at 0x14ae2)"
      tindex a:0xfc4cfa00 %l 0x814ae20 0x14ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO11_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_TEST2 (at 0x14ae3)"
      tindex a:0xfc4cfa00 %l 0x814ae30 0x14ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO11_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_TRIM_NUM (at 0x14af0)"
      tindex a:0xfc4cfa00 %l 0x814af00 0x14af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO11_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO11_TRIM_CTRL (at 0x14af1)"
      tindex a:0xfc4cfa00 %l 0x814af10 0x14af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_REVISION1 (at 0x14b00)"
      tindex a:0xfc4cfa00 %l 0x814b000 0x14b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_REVISION2 (at 0x14b01)"
      tindex a:0xfc4cfa00 %l 0x814b010 0x14b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_REVISION3 (at 0x14b02)"
      tindex a:0xfc4cfa00 %l 0x814b020 0x14b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_REVISION4 (at 0x14b03)"
      tindex a:0xfc4cfa00 %l 0x814b030 0x14b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_TYPE (at 0x14b04)"
      tindex a:0xfc4cfa00 %l 0x814b040 0x14b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_SUBTYPE (at 0x14b05)"
      tindex a:0xfc4cfa00 %l 0x814b050 0x14b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_STATUS1 (at 0x14b08)"
      tindex a:0xfc4cfa00 %l 0x814b080 0x14b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO12_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_STATUS2 (at 0x14b09)"
      tindex a:0xfc4cfa00 %l 0x814b090 0x14b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO12_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_STATUS3 (at 0x14b0a)"
      tindex a:0xfc4cfa00 %l 0x814b0a0 0x14b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO12_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_RT_STS (at 0x14b10)"
      tindex a:0xfc4cfa00 %l 0x814b100 0x14b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_SET_TYPE (at 0x14b11)"
      tindex a:0xfc4cfa00 %l 0x814b110 0x14b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
      tindex a:0xfc4cfa00 %l 0x814b120 0x14b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_POLARITY_LOW (at 0x14b13)"
      tindex a:0xfc4cfa00 %l 0x814b130 0x14b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_LATCHED_CLR (at 0x14b14)"
      tindex a:0xfc4cfa00 %l 0x814b140 0x14b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO12_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_EN_SET (at 0x14b15)"
      tindex a:0xfc4cfa00 %l 0x814b150 0x14b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_EN_CLR (at 0x14b16)"
      tindex a:0xfc4cfa00 %l 0x814b160 0x14b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_LATCHED_STS (at 0x14b18)"
      tindex a:0xfc4cfa00 %l 0x814b180 0x14b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_PENDING_STS (at 0x14b19)"
      tindex a:0xfc4cfa00 %l 0x814b190 0x14b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_MID_SEL (at 0x14b1a)"
      tindex a:0xfc4cfa00 %l 0x814b1a0 0x14b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO12_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_PRIORITY (at 0x14b1b)"
      tindex a:0xfc4cfa00 %l 0x814b1b0 0x14b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO12_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_VOLTAGE_CTL1 (at 0x14b40)"
      tindex a:0xfc4cfa00 %l 0x814b400 0x14b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_VOLTAGE_CTL2 (at 0x14b41)"
      tindex a:0xfc4cfa00 %l 0x814b410 0x14b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO12_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_MODE_CTL2 (at 0x14b45)"
      tindex a:0xfc4cfa00 %l 0x814b450 0x14b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_EN_CTL (at 0x14b46)"
      tindex a:0xfc4cfa00 %l 0x814b460 0x14b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PD_CTL (at 0x14b48)"
      tindex a:0xfc4cfa00 %l 0x814b480 0x14b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO12_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_CURRENT_LIM_CTL (at 0x14b4a)"
      tindex a:0xfc4cfa00 %l 0x814b4a0 0x14b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO12_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_SOFT_START_CTL (at 0x14b4c)"
      tindex a:0xfc4cfa00 %l 0x814b4c0 0x14b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO12_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_CONFIG_CTL (at 0x14b52)"
      tindex a:0xfc4cfa00 %l 0x814b520 0x14b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_LL_VOLTAGE_CTL1 (at 0x14b68)"
      tindex a:0xfc4cfa00 %l 0x814b680 0x14b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_LL_VOLTAGE_CTL2 (at 0x14b69)"
      tindex a:0xfc4cfa00 %l 0x814b690 0x14b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_UL_VOLTAGE_CTL1 (at 0x14b6a)"
      tindex a:0xfc4cfa00 %l 0x814b6a0 0x14b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_UL_VOLTAGE_CTL2 (at 0x14b6b)"
      tindex a:0xfc4cfa00 %l 0x814b6b0 0x14b6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO12_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_SEC_ACCESS (at 0x14bd0)"
      tindex a:0xfc4cfa00 %l 0x814bd00 0x14bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
      tindex a:0xfc4cfa00 %l 0x814bd80 0x14bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
      tindex a:0xfc4cfa00 %l 0x814bd90 0x14bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
      tindex a:0xfc4cfa00 %l 0x814bda0 0x14bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
      tindex a:0xfc4cfa00 %l 0x814bdb0 0x14bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO12_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_TEST1 (at 0x14be0)"
      tindex a:0xfc4cfa00 %l 0x814be00 0x14be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_INT_TEST_VAL (at 0x14be1)"
      tindex a:0xfc4cfa00 %l 0x814be10 0x14be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO12_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_TEST1 (at 0x14be2)"
      tindex a:0xfc4cfa00 %l 0x814be20 0x14be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_TEST2 (at 0x14be3)"
      tindex a:0xfc4cfa00 %l 0x814be30 0x14be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO12_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_TRIM_NUM (at 0x14bf0)"
      tindex a:0xfc4cfa00 %l 0x814bf00 0x14bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO12_TRIM_CTRL (at 0x14bf1)"
      tindex a:0xfc4cfa00 %l 0x814bf10 0x14bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_REVISION1 (at 0x14c00)"
      tindex a:0xfc4cfa00 %l 0x814c000 0x14c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_REVISION2 (at 0x14c01)"
      tindex a:0xfc4cfa00 %l 0x814c010 0x14c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_REVISION3 (at 0x14c02)"
      tindex a:0xfc4cfa00 %l 0x814c020 0x14c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_REVISION4 (at 0x14c03)"
      tindex a:0xfc4cfa00 %l 0x814c030 0x14c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_TYPE (at 0x14c04)"
      tindex a:0xfc4cfa00 %l 0x814c040 0x14c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_SUBTYPE (at 0x14c05)"
      tindex a:0xfc4cfa00 %l 0x814c050 0x14c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_STATUS1 (at 0x14c08)"
      tindex a:0xfc4cfa00 %l 0x814c080 0x14c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO13_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_STATUS2 (at 0x14c09)"
      tindex a:0xfc4cfa00 %l 0x814c090 0x14c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO13_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_STATUS3 (at 0x14c0a)"
      tindex a:0xfc4cfa00 %l 0x814c0a0 0x14c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO13_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_RT_STS (at 0x14c10)"
      tindex a:0xfc4cfa00 %l 0x814c100 0x14c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_SET_TYPE (at 0x14c11)"
      tindex a:0xfc4cfa00 %l 0x814c110 0x14c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_POLARITY_HIGH (at 0x14c12)"
      tindex a:0xfc4cfa00 %l 0x814c120 0x14c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_POLARITY_LOW (at 0x14c13)"
      tindex a:0xfc4cfa00 %l 0x814c130 0x14c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO13_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_LATCHED_CLR (at 0x14c14)"
      tindex a:0xfc4cfa00 %l 0x814c140 0x14c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO13_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_EN_SET (at 0x14c15)"
      tindex a:0xfc4cfa00 %l 0x814c150 0x14c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_EN_CLR (at 0x14c16)"
      tindex a:0xfc4cfa00 %l 0x814c160 0x14c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_LATCHED_STS (at 0x14c18)"
      tindex a:0xfc4cfa00 %l 0x814c180 0x14c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO13_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_PENDING_STS (at 0x14c19)"
      tindex a:0xfc4cfa00 %l 0x814c190 0x14c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_MID_SEL (at 0x14c1a)"
      tindex a:0xfc4cfa00 %l 0x814c1a0 0x14c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO13_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_PRIORITY (at 0x14c1b)"
      tindex a:0xfc4cfa00 %l 0x814c1b0 0x14c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO13_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_VOLTAGE_CTL1 (at 0x14c40)"
      tindex a:0xfc4cfa00 %l 0x814c400 0x14c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_VOLTAGE_CTL2 (at 0x14c41)"
      tindex a:0xfc4cfa00 %l 0x814c410 0x14c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO13_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_MODE_CTL2 (at 0x14c45)"
      tindex a:0xfc4cfa00 %l 0x814c450 0x14c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_EN_CTL (at 0x14c46)"
      tindex a:0xfc4cfa00 %l 0x814c460 0x14c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PD_CTL (at 0x14c48)"
      tindex a:0xfc4cfa00 %l 0x814c480 0x14c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO13_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_CURRENT_LIM_CTL (at 0x14c4a)"
      tindex a:0xfc4cfa00 %l 0x814c4a0 0x14c4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO13_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_SOFT_START_CTL (at 0x14c4c)"
      tindex a:0xfc4cfa00 %l 0x814c4c0 0x14c4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO13_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_CONFIG_CTL (at 0x14c52)"
      tindex a:0xfc4cfa00 %l 0x814c520 0x14c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_LL_VOLTAGE_CTL1 (at 0x14c68)"
      tindex a:0xfc4cfa00 %l 0x814c680 0x14c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_LL_VOLTAGE_CTL2 (at 0x14c69)"
      tindex a:0xfc4cfa00 %l 0x814c690 0x14c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_UL_VOLTAGE_CTL1 (at 0x14c6a)"
      tindex a:0xfc4cfa00 %l 0x814c6a0 0x14c6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_UL_VOLTAGE_CTL2 (at 0x14c6b)"
      tindex a:0xfc4cfa00 %l 0x814c6b0 0x14c6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO13_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_SEC_ACCESS (at 0x14cd0)"
      tindex a:0xfc4cfa00 %l 0x814cd00 0x14cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
      tindex a:0xfc4cfa00 %l 0x814cd80 0x14cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
      tindex a:0xfc4cfa00 %l 0x814cd90 0x14cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
      tindex a:0xfc4cfa00 %l 0x814cda0 0x14cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
      tindex a:0xfc4cfa00 %l 0x814cdb0 0x14cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO13_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_TEST1 (at 0x14ce0)"
      tindex a:0xfc4cfa00 %l 0x814ce00 0x14ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO13_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_INT_TEST_VAL (at 0x14ce1)"
      tindex a:0xfc4cfa00 %l 0x814ce10 0x14ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO13_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_TEST1 (at 0x14ce2)"
      tindex a:0xfc4cfa00 %l 0x814ce20 0x14ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO13_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_TEST2 (at 0x14ce3)"
      tindex a:0xfc4cfa00 %l 0x814ce30 0x14ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO13_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_TRIM_NUM (at 0x14cf0)"
      tindex a:0xfc4cfa00 %l 0x814cf00 0x14cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO13_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO13_TRIM_CTRL (at 0x14cf1)"
      tindex a:0xfc4cfa00 %l 0x814cf10 0x14cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO14"
  tree "LDO14"
    tree "LDO14_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_REVISION1 (at 0x14d00)"
      tindex a:0xfc4cfa00 %l 0x814d000 0x14d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO14_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_REVISION2 (at 0x14d01)"
      tindex a:0xfc4cfa00 %l 0x814d010 0x14d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO14_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_REVISION3 (at 0x14d02)"
      tindex a:0xfc4cfa00 %l 0x814d020 0x14d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO14_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_REVISION4 (at 0x14d03)"
      tindex a:0xfc4cfa00 %l 0x814d030 0x14d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO14_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_TYPE (at 0x14d04)"
      tindex a:0xfc4cfa00 %l 0x814d040 0x14d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO14_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_SUBTYPE (at 0x14d05)"
      tindex a:0xfc4cfa00 %l 0x814d050 0x14d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO14_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_STATUS1 (at 0x14d08)"
      tindex a:0xfc4cfa00 %l 0x814d080 0x14d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO14_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_STATUS2 (at 0x14d09)"
      tindex a:0xfc4cfa00 %l 0x814d090 0x14d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO14_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_STATUS3 (at 0x14d0a)"
      tindex a:0xfc4cfa00 %l 0x814d0a0 0x14d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO14_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_RT_STS (at 0x14d10)"
      tindex a:0xfc4cfa00 %l 0x814d100 0x14d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_SET_TYPE (at 0x14d11)"
      tindex a:0xfc4cfa00 %l 0x814d110 0x14d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_POLARITY_HIGH (at 0x14d12)"
      tindex a:0xfc4cfa00 %l 0x814d120 0x14d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_POLARITY_LOW (at 0x14d13)"
      tindex a:0xfc4cfa00 %l 0x814d130 0x14d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO14_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_LATCHED_CLR (at 0x14d14)"
      tindex a:0xfc4cfa00 %l 0x814d140 0x14d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO14_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_EN_SET (at 0x14d15)"
      tindex a:0xfc4cfa00 %l 0x814d150 0x14d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_EN_CLR (at 0x14d16)"
      tindex a:0xfc4cfa00 %l 0x814d160 0x14d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_LATCHED_STS (at 0x14d18)"
      tindex a:0xfc4cfa00 %l 0x814d180 0x14d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO14_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_PENDING_STS (at 0x14d19)"
      tindex a:0xfc4cfa00 %l 0x814d190 0x14d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_MID_SEL (at 0x14d1a)"
      tindex a:0xfc4cfa00 %l 0x814d1a0 0x14d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO14_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_PRIORITY (at 0x14d1b)"
      tindex a:0xfc4cfa00 %l 0x814d1b0 0x14d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO14_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_VOLTAGE_CTL1 (at 0x14d40)"
      tindex a:0xfc4cfa00 %l 0x814d400 0x14d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_VOLTAGE_CTL2 (at 0x14d41)"
      tindex a:0xfc4cfa00 %l 0x814d410 0x14d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO14_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_MODE_CTL2 (at 0x14d45)"
      tindex a:0xfc4cfa00 %l 0x814d450 0x14d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_EN_CTL (at 0x14d46)"
      tindex a:0xfc4cfa00 %l 0x814d460 0x14d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PD_CTL (at 0x14d48)"
      tindex a:0xfc4cfa00 %l 0x814d480 0x14d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO14_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_CURRENT_LIM_CTL (at 0x14d4a)"
      tindex a:0xfc4cfa00 %l 0x814d4a0 0x14d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO14_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_SOFT_START_CTL (at 0x14d4c)"
      tindex a:0xfc4cfa00 %l 0x814d4c0 0x14d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO14_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_CONFIG_CTL (at 0x14d52)"
      tindex a:0xfc4cfa00 %l 0x814d520 0x14d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_LL_VOLTAGE_CTL1 (at 0x14d68)"
      tindex a:0xfc4cfa00 %l 0x814d680 0x14d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_LL_VOLTAGE_CTL2 (at 0x14d69)"
      tindex a:0xfc4cfa00 %l 0x814d690 0x14d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_UL_VOLTAGE_CTL1 (at 0x14d6a)"
      tindex a:0xfc4cfa00 %l 0x814d6a0 0x14d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_UL_VOLTAGE_CTL2 (at 0x14d6b)"
      tindex a:0xfc4cfa00 %l 0x814d6b0 0x14d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO14_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_SEC_ACCESS (at 0x14dd0)"
      tindex a:0xfc4cfa00 %l 0x814dd00 0x14dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO14_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_RESET_CTL1 (at 0x14dd8)"
      tindex a:0xfc4cfa00 %l 0x814dd80 0x14dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_RESET_CTL2 (at 0x14dd9)"
      tindex a:0xfc4cfa00 %l 0x814dd90 0x14dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_RESET_CTL3 (at 0x14dda)"
      tindex a:0xfc4cfa00 %l 0x814dda0 0x14dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_PERPH_RESET_CTL4 (at 0x14ddb)"
      tindex a:0xfc4cfa00 %l 0x814ddb0 0x14ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO14_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_TEST1 (at 0x14de0)"
      tindex a:0xfc4cfa00 %l 0x814de00 0x14de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO14_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_INT_TEST_VAL (at 0x14de1)"
      tindex a:0xfc4cfa00 %l 0x814de10 0x14de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO14_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_TEST1 (at 0x14de2)"
      tindex a:0xfc4cfa00 %l 0x814de20 0x14de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO14_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_TEST2 (at 0x14de3)"
      tindex a:0xfc4cfa00 %l 0x814de30 0x14de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO14_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_TRIM_NUM (at 0x14df0)"
      tindex a:0xfc4cfa00 %l 0x814df00 0x14df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO14_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO14_TRIM_CTRL (at 0x14df1)"
      tindex a:0xfc4cfa00 %l 0x814df10 0x14df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO15"
  tree "LDO15"
    tree "LDO15_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_REVISION1 (at 0x14e00)"
      tindex a:0xfc4cfa00 %l 0x814e000 0x14e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO15_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_REVISION2 (at 0x14e01)"
      tindex a:0xfc4cfa00 %l 0x814e010 0x14e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO15_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_REVISION3 (at 0x14e02)"
      tindex a:0xfc4cfa00 %l 0x814e020 0x14e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO15_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_REVISION4 (at 0x14e03)"
      tindex a:0xfc4cfa00 %l 0x814e030 0x14e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO15_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_TYPE (at 0x14e04)"
      tindex a:0xfc4cfa00 %l 0x814e040 0x14e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO15_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_SUBTYPE (at 0x14e05)"
      tindex a:0xfc4cfa00 %l 0x814e050 0x14e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO15_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_STATUS1 (at 0x14e08)"
      tindex a:0xfc4cfa00 %l 0x814e080 0x14e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO15_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_STATUS2 (at 0x14e09)"
      tindex a:0xfc4cfa00 %l 0x814e090 0x14e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO15_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_STATUS3 (at 0x14e0a)"
      tindex a:0xfc4cfa00 %l 0x814e0a0 0x14e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO15_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_RT_STS (at 0x14e10)"
      tindex a:0xfc4cfa00 %l 0x814e100 0x14e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_SET_TYPE (at 0x14e11)"
      tindex a:0xfc4cfa00 %l 0x814e110 0x14e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_POLARITY_HIGH (at 0x14e12)"
      tindex a:0xfc4cfa00 %l 0x814e120 0x14e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_POLARITY_LOW (at 0x14e13)"
      tindex a:0xfc4cfa00 %l 0x814e130 0x14e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO15_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_LATCHED_CLR (at 0x14e14)"
      tindex a:0xfc4cfa00 %l 0x814e140 0x14e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO15_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_EN_SET (at 0x14e15)"
      tindex a:0xfc4cfa00 %l 0x814e150 0x14e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_EN_CLR (at 0x14e16)"
      tindex a:0xfc4cfa00 %l 0x814e160 0x14e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_LATCHED_STS (at 0x14e18)"
      tindex a:0xfc4cfa00 %l 0x814e180 0x14e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO15_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_PENDING_STS (at 0x14e19)"
      tindex a:0xfc4cfa00 %l 0x814e190 0x14e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_MID_SEL (at 0x14e1a)"
      tindex a:0xfc4cfa00 %l 0x814e1a0 0x14e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO15_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_PRIORITY (at 0x14e1b)"
      tindex a:0xfc4cfa00 %l 0x814e1b0 0x14e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO15_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_VOLTAGE_CTL1 (at 0x14e40)"
      tindex a:0xfc4cfa00 %l 0x814e400 0x14e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_VOLTAGE_CTL2 (at 0x14e41)"
      tindex a:0xfc4cfa00 %l 0x814e410 0x14e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO15_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_MODE_CTL2 (at 0x14e45)"
      tindex a:0xfc4cfa00 %l 0x814e450 0x14e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_EN_CTL (at 0x14e46)"
      tindex a:0xfc4cfa00 %l 0x814e460 0x14e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PD_CTL (at 0x14e48)"
      tindex a:0xfc4cfa00 %l 0x814e480 0x14e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO15_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_CURRENT_LIM_CTL (at 0x14e4a)"
      tindex a:0xfc4cfa00 %l 0x814e4a0 0x14e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO15_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_SOFT_START_CTL (at 0x14e4c)"
      tindex a:0xfc4cfa00 %l 0x814e4c0 0x14e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO15_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_CONFIG_CTL (at 0x14e52)"
      tindex a:0xfc4cfa00 %l 0x814e520 0x14e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_LL_VOLTAGE_CTL1 (at 0x14e68)"
      tindex a:0xfc4cfa00 %l 0x814e680 0x14e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_LL_VOLTAGE_CTL2 (at 0x14e69)"
      tindex a:0xfc4cfa00 %l 0x814e690 0x14e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_UL_VOLTAGE_CTL1 (at 0x14e6a)"
      tindex a:0xfc4cfa00 %l 0x814e6a0 0x14e6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_UL_VOLTAGE_CTL2 (at 0x14e6b)"
      tindex a:0xfc4cfa00 %l 0x814e6b0 0x14e6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO15_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_SEC_ACCESS (at 0x14ed0)"
      tindex a:0xfc4cfa00 %l 0x814ed00 0x14ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO15_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_RESET_CTL1 (at 0x14ed8)"
      tindex a:0xfc4cfa00 %l 0x814ed80 0x14ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_RESET_CTL2 (at 0x14ed9)"
      tindex a:0xfc4cfa00 %l 0x814ed90 0x14ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_RESET_CTL3 (at 0x14eda)"
      tindex a:0xfc4cfa00 %l 0x814eda0 0x14eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_PERPH_RESET_CTL4 (at 0x14edb)"
      tindex a:0xfc4cfa00 %l 0x814edb0 0x14edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO15_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_TEST1 (at 0x14ee0)"
      tindex a:0xfc4cfa00 %l 0x814ee00 0x14ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO15_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_INT_TEST_VAL (at 0x14ee1)"
      tindex a:0xfc4cfa00 %l 0x814ee10 0x14ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO15_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_TEST1 (at 0x14ee2)"
      tindex a:0xfc4cfa00 %l 0x814ee20 0x14ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO15_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_TEST2 (at 0x14ee3)"
      tindex a:0xfc4cfa00 %l 0x814ee30 0x14ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO15_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_TRIM_NUM (at 0x14ef0)"
      tindex a:0xfc4cfa00 %l 0x814ef00 0x14ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO15_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO15_TRIM_CTRL (at 0x14ef1)"
      tindex a:0xfc4cfa00 %l 0x814ef10 0x14ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO16"
  tree "LDO16"
    tree "LDO16_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_REVISION1 (at 0x14f00)"
      tindex a:0xfc4cfa00 %l 0x814f000 0x14f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO16_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_REVISION2 (at 0x14f01)"
      tindex a:0xfc4cfa00 %l 0x814f010 0x14f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO16_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_REVISION3 (at 0x14f02)"
      tindex a:0xfc4cfa00 %l 0x814f020 0x14f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO16_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_REVISION4 (at 0x14f03)"
      tindex a:0xfc4cfa00 %l 0x814f030 0x14f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO16_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_TYPE (at 0x14f04)"
      tindex a:0xfc4cfa00 %l 0x814f040 0x14f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO16_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_SUBTYPE (at 0x14f05)"
      tindex a:0xfc4cfa00 %l 0x814f050 0x14f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO16_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_STATUS1 (at 0x14f08)"
      tindex a:0xfc4cfa00 %l 0x814f080 0x14f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO16_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_STATUS2 (at 0x14f09)"
      tindex a:0xfc4cfa00 %l 0x814f090 0x14f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO16_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_STATUS3 (at 0x14f0a)"
      tindex a:0xfc4cfa00 %l 0x814f0a0 0x14f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO16_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_RT_STS (at 0x14f10)"
      tindex a:0xfc4cfa00 %l 0x814f100 0x14f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_SET_TYPE (at 0x14f11)"
      tindex a:0xfc4cfa00 %l 0x814f110 0x14f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_POLARITY_HIGH (at 0x14f12)"
      tindex a:0xfc4cfa00 %l 0x814f120 0x14f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_POLARITY_LOW (at 0x14f13)"
      tindex a:0xfc4cfa00 %l 0x814f130 0x14f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO16_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_LATCHED_CLR (at 0x14f14)"
      tindex a:0xfc4cfa00 %l 0x814f140 0x14f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO16_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_EN_SET (at 0x14f15)"
      tindex a:0xfc4cfa00 %l 0x814f150 0x14f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_EN_CLR (at 0x14f16)"
      tindex a:0xfc4cfa00 %l 0x814f160 0x14f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_LATCHED_STS (at 0x14f18)"
      tindex a:0xfc4cfa00 %l 0x814f180 0x14f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO16_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_PENDING_STS (at 0x14f19)"
      tindex a:0xfc4cfa00 %l 0x814f190 0x14f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_MID_SEL (at 0x14f1a)"
      tindex a:0xfc4cfa00 %l 0x814f1a0 0x14f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO16_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_PRIORITY (at 0x14f1b)"
      tindex a:0xfc4cfa00 %l 0x814f1b0 0x14f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO16_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_VOLTAGE_CTL1 (at 0x14f40)"
      tindex a:0xfc4cfa00 %l 0x814f400 0x14f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_VOLTAGE_CTL2 (at 0x14f41)"
      tindex a:0xfc4cfa00 %l 0x814f410 0x14f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO16_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_MODE_CTL2 (at 0x14f45)"
      tindex a:0xfc4cfa00 %l 0x814f450 0x14f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_EN_CTL (at 0x14f46)"
      tindex a:0xfc4cfa00 %l 0x814f460 0x14f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PD_CTL (at 0x14f48)"
      tindex a:0xfc4cfa00 %l 0x814f480 0x14f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO16_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_CURRENT_LIM_CTL (at 0x14f4a)"
      tindex a:0xfc4cfa00 %l 0x814f4a0 0x14f4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO16_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_SOFT_START_CTL (at 0x14f4c)"
      tindex a:0xfc4cfa00 %l 0x814f4c0 0x14f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO16_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_CONFIG_CTL (at 0x14f52)"
      tindex a:0xfc4cfa00 %l 0x814f520 0x14f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_LL_VOLTAGE_CTL1 (at 0x14f68)"
      tindex a:0xfc4cfa00 %l 0x814f680 0x14f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_LL_VOLTAGE_CTL2 (at 0x14f69)"
      tindex a:0xfc4cfa00 %l 0x814f690 0x14f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_UL_VOLTAGE_CTL1 (at 0x14f6a)"
      tindex a:0xfc4cfa00 %l 0x814f6a0 0x14f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_UL_VOLTAGE_CTL2 (at 0x14f6b)"
      tindex a:0xfc4cfa00 %l 0x814f6b0 0x14f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO16_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_SEC_ACCESS (at 0x14fd0)"
      tindex a:0xfc4cfa00 %l 0x814fd00 0x14fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO16_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_RESET_CTL1 (at 0x14fd8)"
      tindex a:0xfc4cfa00 %l 0x814fd80 0x14fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_RESET_CTL2 (at 0x14fd9)"
      tindex a:0xfc4cfa00 %l 0x814fd90 0x14fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_RESET_CTL3 (at 0x14fda)"
      tindex a:0xfc4cfa00 %l 0x814fda0 0x14fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_PERPH_RESET_CTL4 (at 0x14fdb)"
      tindex a:0xfc4cfa00 %l 0x814fdb0 0x14fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO16_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_TEST1 (at 0x14fe0)"
      tindex a:0xfc4cfa00 %l 0x814fe00 0x14fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO16_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_INT_TEST_VAL (at 0x14fe1)"
      tindex a:0xfc4cfa00 %l 0x814fe10 0x14fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO16_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_TEST1 (at 0x14fe2)"
      tindex a:0xfc4cfa00 %l 0x814fe20 0x14fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO16_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_TEST2 (at 0x14fe3)"
      tindex a:0xfc4cfa00 %l 0x814fe30 0x14fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO16_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_TRIM_NUM (at 0x14ff0)"
      tindex a:0xfc4cfa00 %l 0x814ff00 0x14ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO16_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO16_TRIM_CTRL (at 0x14ff1)"
      tindex a:0xfc4cfa00 %l 0x814ff10 0x14ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO2"
  tree "LDO2"
    tree "LDO2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_REVISION1 (at 0x14100)"
      tindex a:0xfc4cfa00 %l 0x8141000 0x141000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_REVISION2 (at 0x14101)"
      tindex a:0xfc4cfa00 %l 0x8141010 0x141010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_REVISION3 (at 0x14102)"
      tindex a:0xfc4cfa00 %l 0x8141020 0x141020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_REVISION4 (at 0x14103)"
      tindex a:0xfc4cfa00 %l 0x8141030 0x141030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_TYPE (at 0x14104)"
      tindex a:0xfc4cfa00 %l 0x8141040 0x141040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_SUBTYPE (at 0x14105)"
      tindex a:0xfc4cfa00 %l 0x8141050 0x141050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_STATUS1 (at 0x14108)"
      tindex a:0xfc4cfa00 %l 0x8141080 0x141080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO2_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_STATUS2 (at 0x14109)"
      tindex a:0xfc4cfa00 %l 0x8141090 0x141090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO2_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_STATUS3 (at 0x1410a)"
      tindex a:0xfc4cfa00 %l 0x81410a0 0x1410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_RT_STS (at 0x14110)"
      tindex a:0xfc4cfa00 %l 0x8141100 0x141100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_SET_TYPE (at 0x14111)"
      tindex a:0xfc4cfa00 %l 0x8141110 0x141110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_POLARITY_HIGH (at 0x14112)"
      tindex a:0xfc4cfa00 %l 0x8141120 0x141120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_POLARITY_LOW (at 0x14113)"
      tindex a:0xfc4cfa00 %l 0x8141130 0x141130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_LATCHED_CLR (at 0x14114)"
      tindex a:0xfc4cfa00 %l 0x8141140 0x141140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_EN_SET (at 0x14115)"
      tindex a:0xfc4cfa00 %l 0x8141150 0x141150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_EN_CLR (at 0x14116)"
      tindex a:0xfc4cfa00 %l 0x8141160 0x141160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_LATCHED_STS (at 0x14118)"
      tindex a:0xfc4cfa00 %l 0x8141180 0x141180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_PENDING_STS (at 0x14119)"
      tindex a:0xfc4cfa00 %l 0x8141190 0x141190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_MID_SEL (at 0x1411a)"
      tindex a:0xfc4cfa00 %l 0x81411a0 0x1411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_PRIORITY (at 0x1411b)"
      tindex a:0xfc4cfa00 %l 0x81411b0 0x1411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO2_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_VOLTAGE_CTL1 (at 0x14140)"
      tindex a:0xfc4cfa00 %l 0x8141400 0x141400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_VOLTAGE_CTL2 (at 0x14141)"
      tindex a:0xfc4cfa00 %l 0x8141410 0x141410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO2_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_MODE_CTL2 (at 0x14145)"
      tindex a:0xfc4cfa00 %l 0x8141450 0x141450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_EN_CTL (at 0x14146)"
      tindex a:0xfc4cfa00 %l 0x8141460 0x141460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PD_CTL (at 0x14148)"
      tindex a:0xfc4cfa00 %l 0x8141480 0x141480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO2_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_CURRENT_LIM_CTL (at 0x1414a)"
      tindex a:0xfc4cfa00 %l 0x81414a0 0x1414a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO2_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_SOFT_START_CTL (at 0x1414c)"
      tindex a:0xfc4cfa00 %l 0x81414c0 0x1414c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO2_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_CONFIG_CTL (at 0x14152)"
      tindex a:0xfc4cfa00 %l 0x8141520 0x141520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO2_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_VS_CTL (at 0x14161)"
      tindex a:0xfc4cfa00 %l 0x8141610 0x141610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_LL_VOLTAGE_CTL1 (at 0x14168)"
      tindex a:0xfc4cfa00 %l 0x8141680 0x141680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_LL_VOLTAGE_CTL2 (at 0x14169)"
      tindex a:0xfc4cfa00 %l 0x8141690 0x141690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_UL_VOLTAGE_CTL1 (at 0x1416a)"
      tindex a:0xfc4cfa00 %l 0x81416a0 0x1416a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_UL_VOLTAGE_CTL2 (at 0x1416b)"
      tindex a:0xfc4cfa00 %l 0x81416b0 0x1416b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_SEC_ACCESS (at 0x141d0)"
      tindex a:0xfc4cfa00 %l 0x8141d00 0x141d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_RESET_CTL1 (at 0x141d8)"
      tindex a:0xfc4cfa00 %l 0x8141d80 0x141d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_RESET_CTL2 (at 0x141d9)"
      tindex a:0xfc4cfa00 %l 0x8141d90 0x141d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_RESET_CTL3 (at 0x141da)"
      tindex a:0xfc4cfa00 %l 0x8141da0 0x141da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_PERPH_RESET_CTL4 (at 0x141db)"
      tindex a:0xfc4cfa00 %l 0x8141db0 0x141db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO2_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_TEST1 (at 0x141e0)"
      tindex a:0xfc4cfa00 %l 0x8141e00 0x141e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO2_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_INT_TEST_VAL (at 0x141e1)"
      tindex a:0xfc4cfa00 %l 0x8141e10 0x141e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO2_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_TEST1 (at 0x141e2)"
      tindex a:0xfc4cfa00 %l 0x8141e20 0x141e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO2_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_TEST2 (at 0x141e3)"
      tindex a:0xfc4cfa00 %l 0x8141e30 0x141e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO2_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_TRIM_NUM (at 0x141f0)"
      tindex a:0xfc4cfa00 %l 0x8141f00 0x141f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO2_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO2_TRIM_CTRL (at 0x141f1)"
      tindex a:0xfc4cfa00 %l 0x8141f10 0x141f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO3"
  tree "LDO3"
    tree "LDO3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_REVISION1 (at 0x14200)"
      tindex a:0xfc4cfa00 %l 0x8142000 0x142000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_REVISION2 (at 0x14201)"
      tindex a:0xfc4cfa00 %l 0x8142010 0x142010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_REVISION3 (at 0x14202)"
      tindex a:0xfc4cfa00 %l 0x8142020 0x142020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_REVISION4 (at 0x14203)"
      tindex a:0xfc4cfa00 %l 0x8142030 0x142030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_TYPE (at 0x14204)"
      tindex a:0xfc4cfa00 %l 0x8142040 0x142040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_SUBTYPE (at 0x14205)"
      tindex a:0xfc4cfa00 %l 0x8142050 0x142050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_STATUS1 (at 0x14208)"
      tindex a:0xfc4cfa00 %l 0x8142080 0x142080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO3_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_STATUS2 (at 0x14209)"
      tindex a:0xfc4cfa00 %l 0x8142090 0x142090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO3_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_STATUS3 (at 0x1420a)"
      tindex a:0xfc4cfa00 %l 0x81420a0 0x1420a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_RT_STS (at 0x14210)"
      tindex a:0xfc4cfa00 %l 0x8142100 0x142100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_SET_TYPE (at 0x14211)"
      tindex a:0xfc4cfa00 %l 0x8142110 0x142110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_POLARITY_HIGH (at 0x14212)"
      tindex a:0xfc4cfa00 %l 0x8142120 0x142120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_POLARITY_LOW (at 0x14213)"
      tindex a:0xfc4cfa00 %l 0x8142130 0x142130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_LATCHED_CLR (at 0x14214)"
      tindex a:0xfc4cfa00 %l 0x8142140 0x142140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_EN_SET (at 0x14215)"
      tindex a:0xfc4cfa00 %l 0x8142150 0x142150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_EN_CLR (at 0x14216)"
      tindex a:0xfc4cfa00 %l 0x8142160 0x142160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_LATCHED_STS (at 0x14218)"
      tindex a:0xfc4cfa00 %l 0x8142180 0x142180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_PENDING_STS (at 0x14219)"
      tindex a:0xfc4cfa00 %l 0x8142190 0x142190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_MID_SEL (at 0x1421a)"
      tindex a:0xfc4cfa00 %l 0x81421a0 0x1421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_PRIORITY (at 0x1421b)"
      tindex a:0xfc4cfa00 %l 0x81421b0 0x1421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO3_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_VOLTAGE_CTL1 (at 0x14240)"
      tindex a:0xfc4cfa00 %l 0x8142400 0x142400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_VOLTAGE_CTL2 (at 0x14241)"
      tindex a:0xfc4cfa00 %l 0x8142410 0x142410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO3_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_MODE_CTL2 (at 0x14245)"
      tindex a:0xfc4cfa00 %l 0x8142450 0x142450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_EN_CTL (at 0x14246)"
      tindex a:0xfc4cfa00 %l 0x8142460 0x142460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PD_CTL (at 0x14248)"
      tindex a:0xfc4cfa00 %l 0x8142480 0x142480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO3_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_CURRENT_LIM_CTL (at 0x1424a)"
      tindex a:0xfc4cfa00 %l 0x81424a0 0x1424a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO3_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_SOFT_START_CTL (at 0x1424c)"
      tindex a:0xfc4cfa00 %l 0x81424c0 0x1424c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO3_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_CONFIG_CTL (at 0x14252)"
      tindex a:0xfc4cfa00 %l 0x8142520 0x142520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO3_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_VS_CTL (at 0x14261)"
      tindex a:0xfc4cfa00 %l 0x8142610 0x142610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_LL_VOLTAGE_CTL1 (at 0x14268)"
      tindex a:0xfc4cfa00 %l 0x8142680 0x142680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_LL_VOLTAGE_CTL2 (at 0x14269)"
      tindex a:0xfc4cfa00 %l 0x8142690 0x142690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_UL_VOLTAGE_CTL1 (at 0x1426a)"
      tindex a:0xfc4cfa00 %l 0x81426a0 0x1426a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_UL_VOLTAGE_CTL2 (at 0x1426b)"
      tindex a:0xfc4cfa00 %l 0x81426b0 0x1426b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_SEC_ACCESS (at 0x142d0)"
      tindex a:0xfc4cfa00 %l 0x8142d00 0x142d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_RESET_CTL1 (at 0x142d8)"
      tindex a:0xfc4cfa00 %l 0x8142d80 0x142d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_RESET_CTL2 (at 0x142d9)"
      tindex a:0xfc4cfa00 %l 0x8142d90 0x142d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_RESET_CTL3 (at 0x142da)"
      tindex a:0xfc4cfa00 %l 0x8142da0 0x142da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_PERPH_RESET_CTL4 (at 0x142db)"
      tindex a:0xfc4cfa00 %l 0x8142db0 0x142db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO3_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_TEST1 (at 0x142e0)"
      tindex a:0xfc4cfa00 %l 0x8142e00 0x142e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO3_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_INT_TEST_VAL (at 0x142e1)"
      tindex a:0xfc4cfa00 %l 0x8142e10 0x142e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO3_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_TEST1 (at 0x142e2)"
      tindex a:0xfc4cfa00 %l 0x8142e20 0x142e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO3_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_TEST2 (at 0x142e3)"
      tindex a:0xfc4cfa00 %l 0x8142e30 0x142e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO3_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_TRIM_NUM (at 0x142f0)"
      tindex a:0xfc4cfa00 %l 0x8142f00 0x142f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO3_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO3_TRIM_CTRL (at 0x142f1)"
      tindex a:0xfc4cfa00 %l 0x8142f10 0x142f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO4"
  tree "LDO4"
    tree "LDO4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_REVISION1 (at 0x14300)"
      tindex a:0xfc4cfa00 %l 0x8143000 0x143000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_REVISION2 (at 0x14301)"
      tindex a:0xfc4cfa00 %l 0x8143010 0x143010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_REVISION3 (at 0x14302)"
      tindex a:0xfc4cfa00 %l 0x8143020 0x143020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_REVISION4 (at 0x14303)"
      tindex a:0xfc4cfa00 %l 0x8143030 0x143030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_TYPE (at 0x14304)"
      tindex a:0xfc4cfa00 %l 0x8143040 0x143040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_SUBTYPE (at 0x14305)"
      tindex a:0xfc4cfa00 %l 0x8143050 0x143050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO4_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_STATUS1 (at 0x14308)"
      tindex a:0xfc4cfa00 %l 0x8143080 0x143080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO4_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_STATUS2 (at 0x14309)"
      tindex a:0xfc4cfa00 %l 0x8143090 0x143090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO4_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_STATUS3 (at 0x1430a)"
      tindex a:0xfc4cfa00 %l 0x81430a0 0x1430a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_RT_STS (at 0x14310)"
      tindex a:0xfc4cfa00 %l 0x8143100 0x143100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_SET_TYPE (at 0x14311)"
      tindex a:0xfc4cfa00 %l 0x8143110 0x143110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_POLARITY_HIGH (at 0x14312)"
      tindex a:0xfc4cfa00 %l 0x8143120 0x143120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_POLARITY_LOW (at 0x14313)"
      tindex a:0xfc4cfa00 %l 0x8143130 0x143130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_LATCHED_CLR (at 0x14314)"
      tindex a:0xfc4cfa00 %l 0x8143140 0x143140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_EN_SET (at 0x14315)"
      tindex a:0xfc4cfa00 %l 0x8143150 0x143150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_EN_CLR (at 0x14316)"
      tindex a:0xfc4cfa00 %l 0x8143160 0x143160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_LATCHED_STS (at 0x14318)"
      tindex a:0xfc4cfa00 %l 0x8143180 0x143180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_PENDING_STS (at 0x14319)"
      tindex a:0xfc4cfa00 %l 0x8143190 0x143190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_MID_SEL (at 0x1431a)"
      tindex a:0xfc4cfa00 %l 0x81431a0 0x1431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_PRIORITY (at 0x1431b)"
      tindex a:0xfc4cfa00 %l 0x81431b0 0x1431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO4_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_VOLTAGE_CTL1 (at 0x14340)"
      tindex a:0xfc4cfa00 %l 0x8143400 0x143400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_VOLTAGE_CTL2 (at 0x14341)"
      tindex a:0xfc4cfa00 %l 0x8143410 0x143410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO4_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_MODE_CTL2 (at 0x14345)"
      tindex a:0xfc4cfa00 %l 0x8143450 0x143450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_EN_CTL (at 0x14346)"
      tindex a:0xfc4cfa00 %l 0x8143460 0x143460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PD_CTL (at 0x14348)"
      tindex a:0xfc4cfa00 %l 0x8143480 0x143480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO4_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_CURRENT_LIM_CTL (at 0x1434a)"
      tindex a:0xfc4cfa00 %l 0x81434a0 0x1434a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO4_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_SOFT_START_CTL (at 0x1434c)"
      tindex a:0xfc4cfa00 %l 0x81434c0 0x1434c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO4_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_CONFIG_CTL (at 0x14352)"
      tindex a:0xfc4cfa00 %l 0x8143520 0x143520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_LL_VOLTAGE_CTL1 (at 0x14368)"
      tindex a:0xfc4cfa00 %l 0x8143680 0x143680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_LL_VOLTAGE_CTL2 (at 0x14369)"
      tindex a:0xfc4cfa00 %l 0x8143690 0x143690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_UL_VOLTAGE_CTL1 (at 0x1436a)"
      tindex a:0xfc4cfa00 %l 0x81436a0 0x1436a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_UL_VOLTAGE_CTL2 (at 0x1436b)"
      tindex a:0xfc4cfa00 %l 0x81436b0 0x1436b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_SEC_ACCESS (at 0x143d0)"
      tindex a:0xfc4cfa00 %l 0x8143d00 0x143d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_RESET_CTL1 (at 0x143d8)"
      tindex a:0xfc4cfa00 %l 0x8143d80 0x143d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_RESET_CTL2 (at 0x143d9)"
      tindex a:0xfc4cfa00 %l 0x8143d90 0x143d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_RESET_CTL3 (at 0x143da)"
      tindex a:0xfc4cfa00 %l 0x8143da0 0x143da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_PERPH_RESET_CTL4 (at 0x143db)"
      tindex a:0xfc4cfa00 %l 0x8143db0 0x143db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO4_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_TEST1 (at 0x143e0)"
      tindex a:0xfc4cfa00 %l 0x8143e00 0x143e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO4_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_INT_TEST_VAL (at 0x143e1)"
      tindex a:0xfc4cfa00 %l 0x8143e10 0x143e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO4_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_TEST1 (at 0x143e2)"
      tindex a:0xfc4cfa00 %l 0x8143e20 0x143e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO4_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_TEST2 (at 0x143e3)"
      tindex a:0xfc4cfa00 %l 0x8143e30 0x143e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO4_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_TRIM_NUM (at 0x143f0)"
      tindex a:0xfc4cfa00 %l 0x8143f00 0x143f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO4_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO4_TRIM_CTRL (at 0x143f1)"
      tindex a:0xfc4cfa00 %l 0x8143f10 0x143f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO5"
  tree "LDO5"
    tree "LDO5_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_REVISION1 (at 0x14400)"
      tindex a:0xfc4cfa00 %l 0x8144000 0x144000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO5_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_REVISION2 (at 0x14401)"
      tindex a:0xfc4cfa00 %l 0x8144010 0x144010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO5_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_REVISION3 (at 0x14402)"
      tindex a:0xfc4cfa00 %l 0x8144020 0x144020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO5_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_REVISION4 (at 0x14403)"
      tindex a:0xfc4cfa00 %l 0x8144030 0x144030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO5_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_TYPE (at 0x14404)"
      tindex a:0xfc4cfa00 %l 0x8144040 0x144040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO5_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_SUBTYPE (at 0x14405)"
      tindex a:0xfc4cfa00 %l 0x8144050 0x144050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO5_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_STATUS1 (at 0x14408)"
      tindex a:0xfc4cfa00 %l 0x8144080 0x144080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO5_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_STATUS2 (at 0x14409)"
      tindex a:0xfc4cfa00 %l 0x8144090 0x144090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO5_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_STATUS3 (at 0x1440a)"
      tindex a:0xfc4cfa00 %l 0x81440a0 0x1440a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO5_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_RT_STS (at 0x14410)"
      tindex a:0xfc4cfa00 %l 0x8144100 0x144100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_SET_TYPE (at 0x14411)"
      tindex a:0xfc4cfa00 %l 0x8144110 0x144110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_POLARITY_HIGH (at 0x14412)"
      tindex a:0xfc4cfa00 %l 0x8144120 0x144120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_POLARITY_LOW (at 0x14413)"
      tindex a:0xfc4cfa00 %l 0x8144130 0x144130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO5_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_LATCHED_CLR (at 0x14414)"
      tindex a:0xfc4cfa00 %l 0x8144140 0x144140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO5_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_EN_SET (at 0x14415)"
      tindex a:0xfc4cfa00 %l 0x8144150 0x144150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_EN_CLR (at 0x14416)"
      tindex a:0xfc4cfa00 %l 0x8144160 0x144160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_LATCHED_STS (at 0x14418)"
      tindex a:0xfc4cfa00 %l 0x8144180 0x144180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO5_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_PENDING_STS (at 0x14419)"
      tindex a:0xfc4cfa00 %l 0x8144190 0x144190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_MID_SEL (at 0x1441a)"
      tindex a:0xfc4cfa00 %l 0x81441a0 0x1441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO5_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_PRIORITY (at 0x1441b)"
      tindex a:0xfc4cfa00 %l 0x81441b0 0x1441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO5_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_VOLTAGE_CTL1 (at 0x14440)"
      tindex a:0xfc4cfa00 %l 0x8144400 0x144400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_VOLTAGE_CTL2 (at 0x14441)"
      tindex a:0xfc4cfa00 %l 0x8144410 0x144410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO5_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_MODE_CTL2 (at 0x14445)"
      tindex a:0xfc4cfa00 %l 0x8144450 0x144450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_EN_CTL (at 0x14446)"
      tindex a:0xfc4cfa00 %l 0x8144460 0x144460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PD_CTL (at 0x14448)"
      tindex a:0xfc4cfa00 %l 0x8144480 0x144480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO5_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_CURRENT_LIM_CTL (at 0x1444a)"
      tindex a:0xfc4cfa00 %l 0x81444a0 0x1444a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO5_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_SOFT_START_CTL (at 0x1444c)"
      tindex a:0xfc4cfa00 %l 0x81444c0 0x1444c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO5_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_CONFIG_CTL (at 0x14452)"
      tindex a:0xfc4cfa00 %l 0x8144520 0x144520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_LL_VOLTAGE_CTL1 (at 0x14468)"
      tindex a:0xfc4cfa00 %l 0x8144680 0x144680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_LL_VOLTAGE_CTL2 (at 0x14469)"
      tindex a:0xfc4cfa00 %l 0x8144690 0x144690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_UL_VOLTAGE_CTL1 (at 0x1446a)"
      tindex a:0xfc4cfa00 %l 0x81446a0 0x1446a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_UL_VOLTAGE_CTL2 (at 0x1446b)"
      tindex a:0xfc4cfa00 %l 0x81446b0 0x1446b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO5_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_SEC_ACCESS (at 0x144d0)"
      tindex a:0xfc4cfa00 %l 0x8144d00 0x144d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO5_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_RESET_CTL1 (at 0x144d8)"
      tindex a:0xfc4cfa00 %l 0x8144d80 0x144d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_RESET_CTL2 (at 0x144d9)"
      tindex a:0xfc4cfa00 %l 0x8144d90 0x144d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_RESET_CTL3 (at 0x144da)"
      tindex a:0xfc4cfa00 %l 0x8144da0 0x144da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_PERPH_RESET_CTL4 (at 0x144db)"
      tindex a:0xfc4cfa00 %l 0x8144db0 0x144db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO5_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_TEST1 (at 0x144e0)"
      tindex a:0xfc4cfa00 %l 0x8144e00 0x144e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO5_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_INT_TEST_VAL (at 0x144e1)"
      tindex a:0xfc4cfa00 %l 0x8144e10 0x144e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO5_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_TEST1 (at 0x144e2)"
      tindex a:0xfc4cfa00 %l 0x8144e20 0x144e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO5_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_TEST2 (at 0x144e3)"
      tindex a:0xfc4cfa00 %l 0x8144e30 0x144e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO5_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_TRIM_NUM (at 0x144f0)"
      tindex a:0xfc4cfa00 %l 0x8144f00 0x144f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO5_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO5_TRIM_CTRL (at 0x144f1)"
      tindex a:0xfc4cfa00 %l 0x8144f10 0x144f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO6"
  tree "LDO6"
    tree "LDO6_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_REVISION1 (at 0x14500)"
      tindex a:0xfc4cfa00 %l 0x8145000 0x145000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO6_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_REVISION2 (at 0x14501)"
      tindex a:0xfc4cfa00 %l 0x8145010 0x145010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO6_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_REVISION3 (at 0x14502)"
      tindex a:0xfc4cfa00 %l 0x8145020 0x145020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO6_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_REVISION4 (at 0x14503)"
      tindex a:0xfc4cfa00 %l 0x8145030 0x145030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO6_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_TYPE (at 0x14504)"
      tindex a:0xfc4cfa00 %l 0x8145040 0x145040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO6_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_SUBTYPE (at 0x14505)"
      tindex a:0xfc4cfa00 %l 0x8145050 0x145050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO6_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_STATUS1 (at 0x14508)"
      tindex a:0xfc4cfa00 %l 0x8145080 0x145080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO6_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_STATUS2 (at 0x14509)"
      tindex a:0xfc4cfa00 %l 0x8145090 0x145090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO6_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_STATUS3 (at 0x1450a)"
      tindex a:0xfc4cfa00 %l 0x81450a0 0x1450a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO6_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_RT_STS (at 0x14510)"
      tindex a:0xfc4cfa00 %l 0x8145100 0x145100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_SET_TYPE (at 0x14511)"
      tindex a:0xfc4cfa00 %l 0x8145110 0x145110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_POLARITY_HIGH (at 0x14512)"
      tindex a:0xfc4cfa00 %l 0x8145120 0x145120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_POLARITY_LOW (at 0x14513)"
      tindex a:0xfc4cfa00 %l 0x8145130 0x145130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO6_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_LATCHED_CLR (at 0x14514)"
      tindex a:0xfc4cfa00 %l 0x8145140 0x145140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO6_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_EN_SET (at 0x14515)"
      tindex a:0xfc4cfa00 %l 0x8145150 0x145150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_EN_CLR (at 0x14516)"
      tindex a:0xfc4cfa00 %l 0x8145160 0x145160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_LATCHED_STS (at 0x14518)"
      tindex a:0xfc4cfa00 %l 0x8145180 0x145180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO6_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_PENDING_STS (at 0x14519)"
      tindex a:0xfc4cfa00 %l 0x8145190 0x145190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_MID_SEL (at 0x1451a)"
      tindex a:0xfc4cfa00 %l 0x81451a0 0x1451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO6_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_PRIORITY (at 0x1451b)"
      tindex a:0xfc4cfa00 %l 0x81451b0 0x1451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO6_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_VOLTAGE_CTL1 (at 0x14540)"
      tindex a:0xfc4cfa00 %l 0x8145400 0x145400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_VOLTAGE_CTL2 (at 0x14541)"
      tindex a:0xfc4cfa00 %l 0x8145410 0x145410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO6_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_MODE_CTL2 (at 0x14545)"
      tindex a:0xfc4cfa00 %l 0x8145450 0x145450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_EN_CTL (at 0x14546)"
      tindex a:0xfc4cfa00 %l 0x8145460 0x145460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PD_CTL (at 0x14548)"
      tindex a:0xfc4cfa00 %l 0x8145480 0x145480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO6_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_CURRENT_LIM_CTL (at 0x1454a)"
      tindex a:0xfc4cfa00 %l 0x81454a0 0x1454a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO6_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_SOFT_START_CTL (at 0x1454c)"
      tindex a:0xfc4cfa00 %l 0x81454c0 0x1454c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO6_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_CONFIG_CTL (at 0x14552)"
      tindex a:0xfc4cfa00 %l 0x8145520 0x145520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_LL_VOLTAGE_CTL1 (at 0x14568)"
      tindex a:0xfc4cfa00 %l 0x8145680 0x145680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_LL_VOLTAGE_CTL2 (at 0x14569)"
      tindex a:0xfc4cfa00 %l 0x8145690 0x145690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_UL_VOLTAGE_CTL1 (at 0x1456a)"
      tindex a:0xfc4cfa00 %l 0x81456a0 0x1456a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_UL_VOLTAGE_CTL2 (at 0x1456b)"
      tindex a:0xfc4cfa00 %l 0x81456b0 0x1456b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO6_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_SEC_ACCESS (at 0x145d0)"
      tindex a:0xfc4cfa00 %l 0x8145d00 0x145d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO6_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_RESET_CTL1 (at 0x145d8)"
      tindex a:0xfc4cfa00 %l 0x8145d80 0x145d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_RESET_CTL2 (at 0x145d9)"
      tindex a:0xfc4cfa00 %l 0x8145d90 0x145d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_RESET_CTL3 (at 0x145da)"
      tindex a:0xfc4cfa00 %l 0x8145da0 0x145da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_PERPH_RESET_CTL4 (at 0x145db)"
      tindex a:0xfc4cfa00 %l 0x8145db0 0x145db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO6_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_TEST1 (at 0x145e0)"
      tindex a:0xfc4cfa00 %l 0x8145e00 0x145e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO6_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_INT_TEST_VAL (at 0x145e1)"
      tindex a:0xfc4cfa00 %l 0x8145e10 0x145e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO6_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_TEST1 (at 0x145e2)"
      tindex a:0xfc4cfa00 %l 0x8145e20 0x145e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO6_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_TEST2 (at 0x145e3)"
      tindex a:0xfc4cfa00 %l 0x8145e30 0x145e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO6_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_TRIM_NUM (at 0x145f0)"
      tindex a:0xfc4cfa00 %l 0x8145f00 0x145f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO6_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO6_TRIM_CTRL (at 0x145f1)"
      tindex a:0xfc4cfa00 %l 0x8145f10 0x145f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO7"
  tree "LDO7"
    tree "LDO7_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_REVISION1 (at 0x14600)"
      tindex a:0xfc4cfa00 %l 0x8146000 0x146000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO7_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_REVISION2 (at 0x14601)"
      tindex a:0xfc4cfa00 %l 0x8146010 0x146010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO7_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_REVISION3 (at 0x14602)"
      tindex a:0xfc4cfa00 %l 0x8146020 0x146020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO7_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_REVISION4 (at 0x14603)"
      tindex a:0xfc4cfa00 %l 0x8146030 0x146030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO7_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_TYPE (at 0x14604)"
      tindex a:0xfc4cfa00 %l 0x8146040 0x146040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO7_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_SUBTYPE (at 0x14605)"
      tindex a:0xfc4cfa00 %l 0x8146050 0x146050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO7_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_STATUS1 (at 0x14608)"
      tindex a:0xfc4cfa00 %l 0x8146080 0x146080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO7_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_STATUS2 (at 0x14609)"
      tindex a:0xfc4cfa00 %l 0x8146090 0x146090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO7_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_STATUS3 (at 0x1460a)"
      tindex a:0xfc4cfa00 %l 0x81460a0 0x1460a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO7_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_RT_STS (at 0x14610)"
      tindex a:0xfc4cfa00 %l 0x8146100 0x146100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_SET_TYPE (at 0x14611)"
      tindex a:0xfc4cfa00 %l 0x8146110 0x146110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_POLARITY_HIGH (at 0x14612)"
      tindex a:0xfc4cfa00 %l 0x8146120 0x146120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_POLARITY_LOW (at 0x14613)"
      tindex a:0xfc4cfa00 %l 0x8146130 0x146130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO7_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_LATCHED_CLR (at 0x14614)"
      tindex a:0xfc4cfa00 %l 0x8146140 0x146140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO7_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_EN_SET (at 0x14615)"
      tindex a:0xfc4cfa00 %l 0x8146150 0x146150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_EN_CLR (at 0x14616)"
      tindex a:0xfc4cfa00 %l 0x8146160 0x146160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_LATCHED_STS (at 0x14618)"
      tindex a:0xfc4cfa00 %l 0x8146180 0x146180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO7_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_PENDING_STS (at 0x14619)"
      tindex a:0xfc4cfa00 %l 0x8146190 0x146190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_MID_SEL (at 0x1461a)"
      tindex a:0xfc4cfa00 %l 0x81461a0 0x1461a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO7_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_PRIORITY (at 0x1461b)"
      tindex a:0xfc4cfa00 %l 0x81461b0 0x1461b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO7_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_VOLTAGE_CTL1 (at 0x14640)"
      tindex a:0xfc4cfa00 %l 0x8146400 0x146400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_VOLTAGE_CTL2 (at 0x14641)"
      tindex a:0xfc4cfa00 %l 0x8146410 0x146410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO7_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_MODE_CTL2 (at 0x14645)"
      tindex a:0xfc4cfa00 %l 0x8146450 0x146450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_EN_CTL (at 0x14646)"
      tindex a:0xfc4cfa00 %l 0x8146460 0x146460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PD_CTL (at 0x14648)"
      tindex a:0xfc4cfa00 %l 0x8146480 0x146480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO7_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_CURRENT_LIM_CTL (at 0x1464a)"
      tindex a:0xfc4cfa00 %l 0x81464a0 0x1464a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO7_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_SOFT_START_CTL (at 0x1464c)"
      tindex a:0xfc4cfa00 %l 0x81464c0 0x1464c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO7_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_CONFIG_CTL (at 0x14652)"
      tindex a:0xfc4cfa00 %l 0x8146520 0x146520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_LL_VOLTAGE_CTL1 (at 0x14668)"
      tindex a:0xfc4cfa00 %l 0x8146680 0x146680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_LL_VOLTAGE_CTL2 (at 0x14669)"
      tindex a:0xfc4cfa00 %l 0x8146690 0x146690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_UL_VOLTAGE_CTL1 (at 0x1466a)"
      tindex a:0xfc4cfa00 %l 0x81466a0 0x1466a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_UL_VOLTAGE_CTL2 (at 0x1466b)"
      tindex a:0xfc4cfa00 %l 0x81466b0 0x1466b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO7_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_SEC_ACCESS (at 0x146d0)"
      tindex a:0xfc4cfa00 %l 0x8146d00 0x146d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO7_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_RESET_CTL1 (at 0x146d8)"
      tindex a:0xfc4cfa00 %l 0x8146d80 0x146d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_RESET_CTL2 (at 0x146d9)"
      tindex a:0xfc4cfa00 %l 0x8146d90 0x146d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_RESET_CTL3 (at 0x146da)"
      tindex a:0xfc4cfa00 %l 0x8146da0 0x146da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_PERPH_RESET_CTL4 (at 0x146db)"
      tindex a:0xfc4cfa00 %l 0x8146db0 0x146db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO7_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_TEST1 (at 0x146e0)"
      tindex a:0xfc4cfa00 %l 0x8146e00 0x146e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO7_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_INT_TEST_VAL (at 0x146e1)"
      tindex a:0xfc4cfa00 %l 0x8146e10 0x146e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO7_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_TEST1 (at 0x146e2)"
      tindex a:0xfc4cfa00 %l 0x8146e20 0x146e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO7_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_TEST2 (at 0x146e3)"
      tindex a:0xfc4cfa00 %l 0x8146e30 0x146e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO7_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_TRIM_NUM (at 0x146f0)"
      tindex a:0xfc4cfa00 %l 0x8146f00 0x146f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO7_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO7_TRIM_CTRL (at 0x146f1)"
      tindex a:0xfc4cfa00 %l 0x8146f10 0x146f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO8"
  tree "LDO8"
    tree "LDO8_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_REVISION1 (at 0x14700)"
      tindex a:0xfc4cfa00 %l 0x8147000 0x147000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO8_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_REVISION2 (at 0x14701)"
      tindex a:0xfc4cfa00 %l 0x8147010 0x147010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO8_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_REVISION3 (at 0x14702)"
      tindex a:0xfc4cfa00 %l 0x8147020 0x147020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO8_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_REVISION4 (at 0x14703)"
      tindex a:0xfc4cfa00 %l 0x8147030 0x147030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO8_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_TYPE (at 0x14704)"
      tindex a:0xfc4cfa00 %l 0x8147040 0x147040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO8_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_SUBTYPE (at 0x14705)"
      tindex a:0xfc4cfa00 %l 0x8147050 0x147050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO8_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_STATUS1 (at 0x14708)"
      tindex a:0xfc4cfa00 %l 0x8147080 0x147080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO8_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_STATUS2 (at 0x14709)"
      tindex a:0xfc4cfa00 %l 0x8147090 0x147090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO8_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_STATUS3 (at 0x1470a)"
      tindex a:0xfc4cfa00 %l 0x81470a0 0x1470a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO8_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_RT_STS (at 0x14710)"
      tindex a:0xfc4cfa00 %l 0x8147100 0x147100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_SET_TYPE (at 0x14711)"
      tindex a:0xfc4cfa00 %l 0x8147110 0x147110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_POLARITY_HIGH (at 0x14712)"
      tindex a:0xfc4cfa00 %l 0x8147120 0x147120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_POLARITY_LOW (at 0x14713)"
      tindex a:0xfc4cfa00 %l 0x8147130 0x147130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO8_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_LATCHED_CLR (at 0x14714)"
      tindex a:0xfc4cfa00 %l 0x8147140 0x147140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO8_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_EN_SET (at 0x14715)"
      tindex a:0xfc4cfa00 %l 0x8147150 0x147150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_EN_CLR (at 0x14716)"
      tindex a:0xfc4cfa00 %l 0x8147160 0x147160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_LATCHED_STS (at 0x14718)"
      tindex a:0xfc4cfa00 %l 0x8147180 0x147180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO8_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_PENDING_STS (at 0x14719)"
      tindex a:0xfc4cfa00 %l 0x8147190 0x147190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_MID_SEL (at 0x1471a)"
      tindex a:0xfc4cfa00 %l 0x81471a0 0x1471a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO8_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_PRIORITY (at 0x1471b)"
      tindex a:0xfc4cfa00 %l 0x81471b0 0x1471b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO8_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_VOLTAGE_CTL1 (at 0x14740)"
      tindex a:0xfc4cfa00 %l 0x8147400 0x147400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_VOLTAGE_CTL2 (at 0x14741)"
      tindex a:0xfc4cfa00 %l 0x8147410 0x147410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO8_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_MODE_CTL2 (at 0x14745)"
      tindex a:0xfc4cfa00 %l 0x8147450 0x147450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_EN_CTL (at 0x14746)"
      tindex a:0xfc4cfa00 %l 0x8147460 0x147460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PD_CTL (at 0x14748)"
      tindex a:0xfc4cfa00 %l 0x8147480 0x147480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO8_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_CURRENT_LIM_CTL (at 0x1474a)"
      tindex a:0xfc4cfa00 %l 0x81474a0 0x1474a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO8_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_SOFT_START_CTL (at 0x1474c)"
      tindex a:0xfc4cfa00 %l 0x81474c0 0x1474c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO8_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_CONFIG_CTL (at 0x14752)"
      tindex a:0xfc4cfa00 %l 0x8147520 0x147520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_LL_VOLTAGE_CTL1 (at 0x14768)"
      tindex a:0xfc4cfa00 %l 0x8147680 0x147680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_LL_VOLTAGE_CTL2 (at 0x14769)"
      tindex a:0xfc4cfa00 %l 0x8147690 0x147690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_UL_VOLTAGE_CTL1 (at 0x1476a)"
      tindex a:0xfc4cfa00 %l 0x81476a0 0x1476a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_UL_VOLTAGE_CTL2 (at 0x1476b)"
      tindex a:0xfc4cfa00 %l 0x81476b0 0x1476b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO8_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_SEC_ACCESS (at 0x147d0)"
      tindex a:0xfc4cfa00 %l 0x8147d00 0x147d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO8_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_RESET_CTL1 (at 0x147d8)"
      tindex a:0xfc4cfa00 %l 0x8147d80 0x147d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_RESET_CTL2 (at 0x147d9)"
      tindex a:0xfc4cfa00 %l 0x8147d90 0x147d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_RESET_CTL3 (at 0x147da)"
      tindex a:0xfc4cfa00 %l 0x8147da0 0x147da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_PERPH_RESET_CTL4 (at 0x147db)"
      tindex a:0xfc4cfa00 %l 0x8147db0 0x147db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO8_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_TEST1 (at 0x147e0)"
      tindex a:0xfc4cfa00 %l 0x8147e00 0x147e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO8_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_INT_TEST_VAL (at 0x147e1)"
      tindex a:0xfc4cfa00 %l 0x8147e10 0x147e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO8_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_TEST1 (at 0x147e2)"
      tindex a:0xfc4cfa00 %l 0x8147e20 0x147e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO8_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_TEST2 (at 0x147e3)"
      tindex a:0xfc4cfa00 %l 0x8147e30 0x147e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO8_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_TRIM_NUM (at 0x147f0)"
      tindex a:0xfc4cfa00 %l 0x8147f00 0x147f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO8_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO8_TRIM_CTRL (at 0x147f1)"
      tindex a:0xfc4cfa00 %l 0x8147f10 0x147f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO9"
  tree "LDO9"
    tree "LDO9_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_REVISION1 (at 0x14800)"
      tindex a:0xfc4cfa00 %l 0x8148000 0x148000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO9_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_REVISION2 (at 0x14801)"
      tindex a:0xfc4cfa00 %l 0x8148010 0x148010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO9_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_REVISION3 (at 0x14802)"
      tindex a:0xfc4cfa00 %l 0x8148020 0x148020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO9_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_REVISION4 (at 0x14803)"
      tindex a:0xfc4cfa00 %l 0x8148030 0x148030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO9_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_TYPE (at 0x14804)"
      tindex a:0xfc4cfa00 %l 0x8148040 0x148040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO9_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_SUBTYPE (at 0x14805)"
      tindex a:0xfc4cfa00 %l 0x8148050 0x148050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO9_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_STATUS1 (at 0x14808)"
      tindex a:0xfc4cfa00 %l 0x8148080 0x148080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO9_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_STATUS2 (at 0x14809)"
      tindex a:0xfc4cfa00 %l 0x8148090 0x148090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO9_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_STATUS3 (at 0x1480a)"
      tindex a:0xfc4cfa00 %l 0x81480a0 0x1480a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO9_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_RT_STS (at 0x14810)"
      tindex a:0xfc4cfa00 %l 0x8148100 0x148100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_SET_TYPE (at 0x14811)"
      tindex a:0xfc4cfa00 %l 0x8148110 0x148110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_POLARITY_HIGH (at 0x14812)"
      tindex a:0xfc4cfa00 %l 0x8148120 0x148120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_POLARITY_LOW (at 0x14813)"
      tindex a:0xfc4cfa00 %l 0x8148130 0x148130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO9_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_LATCHED_CLR (at 0x14814)"
      tindex a:0xfc4cfa00 %l 0x8148140 0x148140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO9_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_EN_SET (at 0x14815)"
      tindex a:0xfc4cfa00 %l 0x8148150 0x148150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_EN_CLR (at 0x14816)"
      tindex a:0xfc4cfa00 %l 0x8148160 0x148160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_LATCHED_STS (at 0x14818)"
      tindex a:0xfc4cfa00 %l 0x8148180 0x148180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO9_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_PENDING_STS (at 0x14819)"
      tindex a:0xfc4cfa00 %l 0x8148190 0x148190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_MID_SEL (at 0x1481a)"
      tindex a:0xfc4cfa00 %l 0x81481a0 0x1481a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO9_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_PRIORITY (at 0x1481b)"
      tindex a:0xfc4cfa00 %l 0x81481b0 0x1481b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO9_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_VOLTAGE_CTL1 (at 0x14840)"
      tindex a:0xfc4cfa00 %l 0x8148400 0x148400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_VOLTAGE_CTL2 (at 0x14841)"
      tindex a:0xfc4cfa00 %l 0x8148410 0x148410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO9_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_MODE_CTL2 (at 0x14845)"
      tindex a:0xfc4cfa00 %l 0x8148450 0x148450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_EN_CTL (at 0x14846)"
      tindex a:0xfc4cfa00 %l 0x8148460 0x148460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PD_CTL (at 0x14848)"
      tindex a:0xfc4cfa00 %l 0x8148480 0x148480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO9_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_CURRENT_LIM_CTL (at 0x1484a)"
      tindex a:0xfc4cfa00 %l 0x81484a0 0x1484a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO9_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_SOFT_START_CTL (at 0x1484c)"
      tindex a:0xfc4cfa00 %l 0x81484c0 0x1484c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO9_CONFIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_CONFIG_CTL (at 0x14852)"
      tindex a:0xfc4cfa00 %l 0x8148520 0x148520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO9_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_VS_CTL (at 0x14861)"
      tindex a:0xfc4cfa00 %l 0x8148610 0x148610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_LL_VOLTAGE_CTL1 (at 0x14868)"
      tindex a:0xfc4cfa00 %l 0x8148680 0x148680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_LL_VOLTAGE_CTL2 (at 0x14869)"
      tindex a:0xfc4cfa00 %l 0x8148690 0x148690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_UL_VOLTAGE_CTL1 (at 0x1486a)"
      tindex a:0xfc4cfa00 %l 0x81486a0 0x1486a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_UL_VOLTAGE_CTL2 (at 0x1486b)"
      tindex a:0xfc4cfa00 %l 0x81486b0 0x1486b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO9_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_SEC_ACCESS (at 0x148d0)"
      tindex a:0xfc4cfa00 %l 0x8148d00 0x148d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO9_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_RESET_CTL1 (at 0x148d8)"
      tindex a:0xfc4cfa00 %l 0x8148d80 0x148d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_RESET_CTL2 (at 0x148d9)"
      tindex a:0xfc4cfa00 %l 0x8148d90 0x148d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_RESET_CTL3 (at 0x148da)"
      tindex a:0xfc4cfa00 %l 0x8148da0 0x148da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_PERPH_RESET_CTL4 (at 0x148db)"
      tindex a:0xfc4cfa00 %l 0x8148db0 0x148db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO9_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_TEST1 (at 0x148e0)"
      tindex a:0xfc4cfa00 %l 0x8148e00 0x148e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO9_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_INT_TEST_VAL (at 0x148e1)"
      tindex a:0xfc4cfa00 %l 0x8148e10 0x148e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO9_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_TEST1 (at 0x148e2)"
      tindex a:0xfc4cfa00 %l 0x8148e20 0x148e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO9_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_TEST2 (at 0x148e3)"
      tindex a:0xfc4cfa00 %l 0x8148e30 0x148e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO9_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_TRIM_NUM (at 0x148f0)"
      tindex a:0xfc4cfa00 %l 0x8148f00 0x148f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO9_TRIM_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO9_TRIM_CTRL (at 0x148f1)"
      tindex a:0xfc4cfa00 %l 0x8148f10 0x148f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO_RFCLK"
  tree "LDO_RFCLK"
    tree "LDO_RFCLK_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_REVISION1 (at 0x15100)"
      tindex a:0xfc4cfa00 %l 0x8151000 0x151000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_REVISION2 (at 0x15101)"
      tindex a:0xfc4cfa00 %l 0x8151010 0x151010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_REVISION3 (at 0x15102)"
      tindex a:0xfc4cfa00 %l 0x8151020 0x151020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_REVISION4 (at 0x15103)"
      tindex a:0xfc4cfa00 %l 0x8151030 0x151030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_TYPE (at 0x15104)"
      tindex a:0xfc4cfa00 %l 0x8151040 0x151040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_RFCLK_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_SUBTYPE (at 0x15105)"
      tindex a:0xfc4cfa00 %l 0x8151050 0x151050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_RFCLK_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_STATUS1 (at 0x15108)"
      tindex a:0xfc4cfa00 %l 0x8151080 0x151080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_VOLTAGE_CTL1 (at 0x15140)"
      tindex a:0xfc4cfa00 %l 0x8151400 0x151400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_VOLTAGE_CTL2 (at 0x15141)"
      tindex a:0xfc4cfa00 %l 0x8151410 0x151410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_RFCLK_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_MODE_CTL2 (at 0x15145)"
      tindex a:0xfc4cfa00 %l 0x8151450 0x151450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_RFCLK_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_EN_CTL (at 0x15146)"
      tindex a:0xfc4cfa00 %l 0x8151460 0x151460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_RFCLK_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_SEC_ACCESS (at 0x151d0)"
      tindex a:0xfc4cfa00 %l 0x8151d00 0x151d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_RESET_CTL1 (at 0x151d8)"
      tindex a:0xfc4cfa00 %l 0x8151d80 0x151d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_RESET_CTL2 (at 0x151d9)"
      tindex a:0xfc4cfa00 %l 0x8151d90 0x151d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_RESET_CTL3 (at 0x151da)"
      tindex a:0xfc4cfa00 %l 0x8151da0 0x151da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_PERPH_RESET_CTL4 (at 0x151db)"
      tindex a:0xfc4cfa00 %l 0x8151db0 0x151db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_RFCLK_TEST1 (at 0x151e2)"
      tindex a:0xfc4cfa00 %l 0x8151e20 0x151e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO_XO"
  tree "LDO_XO"
    tree "LDO_XO_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_REVISION1 (at 0x15000)"
      tindex a:0xfc4cfa00 %l 0x8150000 0x150000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_REVISION2 (at 0x15001)"
      tindex a:0xfc4cfa00 %l 0x8150010 0x150010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_XO_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_REVISION3 (at 0x15002)"
      tindex a:0xfc4cfa00 %l 0x8150020 0x150020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_REVISION4 (at 0x15003)"
      tindex a:0xfc4cfa00 %l 0x8150030 0x150030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_XO_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_TYPE (at 0x15004)"
      tindex a:0xfc4cfa00 %l 0x8150040 0x150040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_XO_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_SUBTYPE (at 0x15005)"
      tindex a:0xfc4cfa00 %l 0x8150050 0x150050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_XO_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_STATUS1 (at 0x15008)"
      tindex a:0xfc4cfa00 %l 0x8150080 0x150080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_VOLTAGE_CTL1 (at 0x15040)"
      tindex a:0xfc4cfa00 %l 0x8150400 0x150400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_VOLTAGE_CTL2 (at 0x15041)"
      tindex a:0xfc4cfa00 %l 0x8150410 0x150410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_XO_MODE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_MODE_CTL2 (at 0x15045)"
      tindex a:0xfc4cfa00 %l 0x8150450 0x150450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_XO_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_EN_CTL (at 0x15046)"
      tindex a:0xfc4cfa00 %l 0x8150460 0x150460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_XO_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_SEC_ACCESS (at 0x150d0)"
      tindex a:0xfc4cfa00 %l 0x8150d00 0x150d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_RESET_CTL1 (at 0x150d8)"
      tindex a:0xfc4cfa00 %l 0x8150d80 0x150d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_RESET_CTL2 (at 0x150d9)"
      tindex a:0xfc4cfa00 %l 0x8150d90 0x150d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_RESET_CTL3 (at 0x150da)"
      tindex a:0xfc4cfa00 %l 0x8150da0 0x150da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_PERPH_RESET_CTL4 (at 0x150db)"
      tindex a:0xfc4cfa00 %l 0x8150db0 0x150db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_XO_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LDO_XO_TEST1 (at 0x150e2)"
      tindex a:0xfc4cfa00 %l 0x8150e20 0x150e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LN_BB_CLK"
  tree "LN_BB_CLK"
    tree "LN_BB_CLK_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_REVISION1 (at 0x5200)"
      tindex a:0xfc4cfa00 %l 0x8052000 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_REVISION2 (at 0x5201)"
      tindex a:0xfc4cfa00 %l 0x8052010 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_REVISION3 (at 0x5202)"
      tindex a:0xfc4cfa00 %l 0x8052020 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_REVISION4 (at 0x5203)"
      tindex a:0xfc4cfa00 %l 0x8052030 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_TYPE (at 0x5204)"
      tindex a:0xfc4cfa00 %l 0x8052040 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LN_BB_CLK_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_SUBTYPE (at 0x5205)"
      tindex a:0xfc4cfa00 %l 0x8052050 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LN_BB_CLK_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_STATUS1 (at 0x5208)"
      tindex a:0xfc4cfa00 %l 0x8052080 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "LN_BB_CLK_EDGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_EDGE_CTL1 (at 0x5243)"
      tindex a:0xfc4cfa00 %l 0x8052430 0x52430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "LN_BB_CLK_DRV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_DRV_CTL1 (at 0x5244)"
      tindex a:0xfc4cfa00 %l 0x8052440 0x52440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_EN_CTL (at 0x5246)"
      tindex a:0xfc4cfa00 %l 0x8052460 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PD_CTL (at 0x5248)"
      tindex a:0xfc4cfa00 %l 0x8052480 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "LN_BB_CLK_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_SEC_ACCESS (at 0x52d0)"
      tindex a:0xfc4cfa00 %l 0x8052d00 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_RESET_CTL1 (at 0x52d8)"
      tindex a:0xfc4cfa00 %l 0x8052d80 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_RESET_CTL2 (at 0x52d9)"
      tindex a:0xfc4cfa00 %l 0x8052d90 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_RESET_CTL3 (at 0x52da)"
      tindex a:0xfc4cfa00 %l 0x8052da0 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "LN_BB_CLK_PERPH_RESET_CTL4 (at 0x52db)"
      tindex a:0xfc4cfa00 %l 0x8052db0 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION1 (at 0x2c00)"
      tindex a:0xfc4cfa00 %l 0x802c000 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION2 (at 0x2c01)"
      tindex a:0xfc4cfa00 %l 0x802c010 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION3 (at 0x2c02)"
      tindex a:0xfc4cfa00 %l 0x802c020 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION4 (at 0x2c03)"
      tindex a:0xfc4cfa00 %l 0x802c030 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_TYPE (at 0x2c04)"
      tindex a:0xfc4cfa00 %l 0x802c040 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_SUBTYPE (at 0x2c05)"
      tindex a:0xfc4cfa00 %l 0x802c050 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_STATUS1 (at 0x2c08)"
      tindex a:0xfc4cfa00 %l 0x802c080 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MODE_CTRL (at 0x2c44)"
      tindex a:0xfc4cfa00 %l 0x802c440 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_EN_CTL (at 0x2c46)"
      tindex a:0xfc4cfa00 %l 0x802c460 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_SEC_ACCESS (at 0x2cd0)"
      tindex a:0xfc4cfa00 %l 0x802cd00 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
      tindex a:0xfc4cfa00 %l 0x802cd80 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
      tindex a:0xfc4cfa00 %l 0x802cd90 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
      tindex a:0xfc4cfa00 %l 0x802cda0 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
      tindex a:0xfc4cfa00 %l 0x802cdb0 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TEST1 (at 0x2ce2)"
      tindex a:0xfc4cfa00 %l 0x802ce20 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TEST2 (at 0x2ce3)"
      tindex a:0xfc4cfa00 %l 0x802ce30 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TRIM_NUM (at 0x2cf0)"
      tindex a:0xfc4cfa00 %l 0x802cf00 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM1 (at 0x2cf1)"
      tindex a:0xfc4cfa00 %l 0x802cf10 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM2 (at 0x2cf2)"
      tindex a:0xfc4cfa00 %l 0x802cf20 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM3 (at 0x2cf3)"
      tindex a:0xfc4cfa00 %l 0x802cf30 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM4 (at 0x2cf4)"
      tindex a:0xfc4cfa00 %l 0x802cf40 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM5 (at 0x2cf5)"
      tindex a:0xfc4cfa00 %l 0x802cf50 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM6 (at 0x2cf6)"
      tindex a:0xfc4cfa00 %l 0x802cf60 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM7 (at 0x2cf7)"
      tindex a:0xfc4cfa00 %l 0x802cf70 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM8 (at 0x2cf8)"
      tindex a:0xfc4cfa00 %l 0x802cf80 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION1 (at 0x900)"
      tindex a:0xfc4cfa00 %l 0x8009000 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION2 (at 0x901)"
      tindex a:0xfc4cfa00 %l 0x8009010 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION3 (at 0x902)"
      tindex a:0xfc4cfa00 %l 0x8009020 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION4 (at 0x903)"
      tindex a:0xfc4cfa00 %l 0x8009030 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_TYPE (at 0x904)"
      tindex a:0xfc4cfa00 %l 0x8009040 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_SUBTYPE (at 0x905)"
      tindex a:0xfc4cfa00 %l 0x8009050 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_STATUS1 (at 0x908)"
      tindex a:0xfc4cfa00 %l 0x8009080 0x9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GP1RESET                                 = " "0, 1"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
      tindex a:0xfc4cfa00 %l 0x8009420 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1"
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_BUCK_CMN_CTL1 (at 0x945)"
      tindex a:0xfc4cfa00 %l 0x8009450 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0, 1"
    tree.end
    tree "MISC_MISC_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_MISC_CTL1 (at 0x946)"
      tindex a:0xfc4cfa00 %l 0x8009460 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x7 1 "  [ 7: 1]   MISC_CTL                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VDD_LDO_XO_SEL                           = " "0, 1"
    tree.end
    tree "MISC_GP1RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_GP1RESET_CTL1 (at 0x947)"
      tindex a:0xfc4cfa00 %l 0x8009470 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO3_GP1RESET_POLARITY                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GPIO3_GP1RESET_EN                        = " "0, 1"
    tree.end
    tree "MISC_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_SEC_ACCESS (at 0x9d0)"
      tindex a:0xfc4cfa00 %l 0x8009d00 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
      tindex a:0xfc4cfa00 %l 0x8009d90 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL3 (at 0x9da)"
      tindex a:0xfc4cfa00 %l 0x8009da0 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL4 (at 0x9db)"
      tindex a:0xfc4cfa00 %l 0x8009db0 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MISC_TEST_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_TEST_ACCESS (at 0x9e0)"
      tindex a:0xfc4cfa00 %l 0x8009e00 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
    tree.end
    tree "MISC_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_TRIM_NUM (at 0x9f0)"
      tindex a:0xfc4cfa00 %l 0x8009f00 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION1 (at 0xa000)"
      tindex a:0xfc4cfa00 %l 0x80a0000 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION2 (at 0xa001)"
      tindex a:0xfc4cfa00 %l 0x80a0010 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION3 (at 0xa002)"
      tindex a:0xfc4cfa00 %l 0x80a0020 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION4 (at 0xa003)"
      tindex a:0xfc4cfa00 %l 0x80a0030 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_TYPE (at 0xa004)"
      tindex a:0xfc4cfa00 %l 0x80a0040 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_SUBTYPE (at 0xa005)"
      tindex a:0xfc4cfa00 %l 0x80a0050 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_STATUS1 (at 0xa008)"
      tindex a:0xfc4cfa00 %l 0x80a0080 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_RT_STS (at 0xa010)"
      tindex a:0xfc4cfa00 %l 0x80a0100 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_SET_TYPE (at 0xa011)"
      tindex a:0xfc4cfa00 %l 0x80a0110 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_POLARITY_HIGH (at 0xa012)"
      tindex a:0xfc4cfa00 %l 0x80a0120 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_POLARITY_LOW (at 0xa013)"
      tindex a:0xfc4cfa00 %l 0x80a0130 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_LATCHED_CLR (at 0xa014)"
      tindex a:0xfc4cfa00 %l 0x80a0140 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_EN_SET (at 0xa015)"
      tindex a:0xfc4cfa00 %l 0x80a0150 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_EN_CLR (at 0xa016)"
      tindex a:0xfc4cfa00 %l 0x80a0160 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_LATCHED_STS (at 0xa018)"
      tindex a:0xfc4cfa00 %l 0x80a0180 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_PENDING_STS (at 0xa019)"
      tindex a:0xfc4cfa00 %l 0x80a0190 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_MID_SEL (at 0xa01a)"
      tindex a:0xfc4cfa00 %l 0x80a01a0 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_PRIORITY (at 0xa01b)"
      tindex a:0xfc4cfa00 %l 0x80a01b0 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_MODE_CTL (at 0xa040)"
      tindex a:0xfc4cfa00 %l 0x80a0400 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_VIN_CTL (at 0xa041)"
      tindex a:0xfc4cfa00 %l 0x80a0410 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_PULL_CTL (at 0xa042)"
      tindex a:0xfc4cfa00 %l 0x80a0420 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_IN_CTL (at 0xa043)"
      tindex a:0xfc4cfa00 %l 0x80a0430 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_EN_CTL (at 0xa046)"
      tindex a:0xfc4cfa00 %l 0x80a0460 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_ANA_OUT_CTL (at 0xa048)"
      tindex a:0xfc4cfa00 %l 0x80a0480 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_ANA_IN_CTL (at 0xa04a)"
      tindex a:0xfc4cfa00 %l 0x80a04a0 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_SINK_CTL (at 0xa04c)"
      tindex a:0xfc4cfa00 %l 0x80a04c0 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_SEC_ACCESS (at 0xa0d0)"
      tindex a:0xfc4cfa00 %l 0x80a0d00 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
      tindex a:0xfc4cfa00 %l 0x80a0d80 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
      tindex a:0xfc4cfa00 %l 0x80a0d90 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
      tindex a:0xfc4cfa00 %l 0x80a0da0 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
      tindex a:0xfc4cfa00 %l 0x80a0db0 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION1 (at 0xa100)"
      tindex a:0xfc4cfa00 %l 0x80a1000 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION2 (at 0xa101)"
      tindex a:0xfc4cfa00 %l 0x80a1010 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION3 (at 0xa102)"
      tindex a:0xfc4cfa00 %l 0x80a1020 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION4 (at 0xa103)"
      tindex a:0xfc4cfa00 %l 0x80a1030 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_TYPE (at 0xa104)"
      tindex a:0xfc4cfa00 %l 0x80a1040 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_SUBTYPE (at 0xa105)"
      tindex a:0xfc4cfa00 %l 0x80a1050 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_STATUS1 (at 0xa108)"
      tindex a:0xfc4cfa00 %l 0x80a1080 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_RT_STS (at 0xa110)"
      tindex a:0xfc4cfa00 %l 0x80a1100 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_SET_TYPE (at 0xa111)"
      tindex a:0xfc4cfa00 %l 0x80a1110 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_POLARITY_HIGH (at 0xa112)"
      tindex a:0xfc4cfa00 %l 0x80a1120 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_POLARITY_LOW (at 0xa113)"
      tindex a:0xfc4cfa00 %l 0x80a1130 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_LATCHED_CLR (at 0xa114)"
      tindex a:0xfc4cfa00 %l 0x80a1140 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_EN_SET (at 0xa115)"
      tindex a:0xfc4cfa00 %l 0x80a1150 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_EN_CLR (at 0xa116)"
      tindex a:0xfc4cfa00 %l 0x80a1160 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_LATCHED_STS (at 0xa118)"
      tindex a:0xfc4cfa00 %l 0x80a1180 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_PENDING_STS (at 0xa119)"
      tindex a:0xfc4cfa00 %l 0x80a1190 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_MID_SEL (at 0xa11a)"
      tindex a:0xfc4cfa00 %l 0x80a11a0 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_PRIORITY (at 0xa11b)"
      tindex a:0xfc4cfa00 %l 0x80a11b0 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_MODE_CTL (at 0xa140)"
      tindex a:0xfc4cfa00 %l 0x80a1400 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_VIN_CTL (at 0xa141)"
      tindex a:0xfc4cfa00 %l 0x80a1410 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_PULL_CTL (at 0xa142)"
      tindex a:0xfc4cfa00 %l 0x80a1420 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_IN_CTL (at 0xa143)"
      tindex a:0xfc4cfa00 %l 0x80a1430 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_EN_CTL (at 0xa146)"
      tindex a:0xfc4cfa00 %l 0x80a1460 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_ANA_OUT_CTL (at 0xa148)"
      tindex a:0xfc4cfa00 %l 0x80a1480 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_ANA_IN_CTL (at 0xa14a)"
      tindex a:0xfc4cfa00 %l 0x80a14a0 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_SINK_CTL (at 0xa14c)"
      tindex a:0xfc4cfa00 %l 0x80a14c0 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_SEC_ACCESS (at 0xa1d0)"
      tindex a:0xfc4cfa00 %l 0x80a1d00 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
      tindex a:0xfc4cfa00 %l 0x80a1d80 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
      tindex a:0xfc4cfa00 %l 0x80a1d90 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
      tindex a:0xfc4cfa00 %l 0x80a1da0 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
      tindex a:0xfc4cfa00 %l 0x80a1db0 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION1 (at 0xa200)"
      tindex a:0xfc4cfa00 %l 0x80a2000 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION2 (at 0xa201)"
      tindex a:0xfc4cfa00 %l 0x80a2010 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION3 (at 0xa202)"
      tindex a:0xfc4cfa00 %l 0x80a2020 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION4 (at 0xa203)"
      tindex a:0xfc4cfa00 %l 0x80a2030 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_TYPE (at 0xa204)"
      tindex a:0xfc4cfa00 %l 0x80a2040 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_SUBTYPE (at 0xa205)"
      tindex a:0xfc4cfa00 %l 0x80a2050 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_STATUS1 (at 0xa208)"
      tindex a:0xfc4cfa00 %l 0x80a2080 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_RT_STS (at 0xa210)"
      tindex a:0xfc4cfa00 %l 0x80a2100 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_SET_TYPE (at 0xa211)"
      tindex a:0xfc4cfa00 %l 0x80a2110 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_POLARITY_HIGH (at 0xa212)"
      tindex a:0xfc4cfa00 %l 0x80a2120 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_POLARITY_LOW (at 0xa213)"
      tindex a:0xfc4cfa00 %l 0x80a2130 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_LATCHED_CLR (at 0xa214)"
      tindex a:0xfc4cfa00 %l 0x80a2140 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_EN_SET (at 0xa215)"
      tindex a:0xfc4cfa00 %l 0x80a2150 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_EN_CLR (at 0xa216)"
      tindex a:0xfc4cfa00 %l 0x80a2160 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_LATCHED_STS (at 0xa218)"
      tindex a:0xfc4cfa00 %l 0x80a2180 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_PENDING_STS (at 0xa219)"
      tindex a:0xfc4cfa00 %l 0x80a2190 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_MID_SEL (at 0xa21a)"
      tindex a:0xfc4cfa00 %l 0x80a21a0 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_PRIORITY (at 0xa21b)"
      tindex a:0xfc4cfa00 %l 0x80a21b0 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_MODE_CTL (at 0xa240)"
      tindex a:0xfc4cfa00 %l 0x80a2400 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_VIN_CTL (at 0xa241)"
      tindex a:0xfc4cfa00 %l 0x80a2410 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_PULL_CTL (at 0xa242)"
      tindex a:0xfc4cfa00 %l 0x80a2420 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_IN_CTL (at 0xa243)"
      tindex a:0xfc4cfa00 %l 0x80a2430 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_EN_CTL (at 0xa246)"
      tindex a:0xfc4cfa00 %l 0x80a2460 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_ANA_OUT_CTL (at 0xa248)"
      tindex a:0xfc4cfa00 %l 0x80a2480 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_ANA_IN_CTL (at 0xa24a)"
      tindex a:0xfc4cfa00 %l 0x80a24a0 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_SINK_CTL (at 0xa24c)"
      tindex a:0xfc4cfa00 %l 0x80a24c0 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_SEC_ACCESS (at 0xa2d0)"
      tindex a:0xfc4cfa00 %l 0x80a2d00 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
      tindex a:0xfc4cfa00 %l 0x80a2d80 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
      tindex a:0xfc4cfa00 %l 0x80a2d90 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
      tindex a:0xfc4cfa00 %l 0x80a2da0 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
      tindex a:0xfc4cfa00 %l 0x80a2db0 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION1 (at 0xa300)"
      tindex a:0xfc4cfa00 %l 0x80a3000 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION2 (at 0xa301)"
      tindex a:0xfc4cfa00 %l 0x80a3010 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION3 (at 0xa302)"
      tindex a:0xfc4cfa00 %l 0x80a3020 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION4 (at 0xa303)"
      tindex a:0xfc4cfa00 %l 0x80a3030 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_TYPE (at 0xa304)"
      tindex a:0xfc4cfa00 %l 0x80a3040 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_SUBTYPE (at 0xa305)"
      tindex a:0xfc4cfa00 %l 0x80a3050 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_STATUS1 (at 0xa308)"
      tindex a:0xfc4cfa00 %l 0x80a3080 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_RT_STS (at 0xa310)"
      tindex a:0xfc4cfa00 %l 0x80a3100 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_SET_TYPE (at 0xa311)"
      tindex a:0xfc4cfa00 %l 0x80a3110 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_POLARITY_HIGH (at 0xa312)"
      tindex a:0xfc4cfa00 %l 0x80a3120 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_POLARITY_LOW (at 0xa313)"
      tindex a:0xfc4cfa00 %l 0x80a3130 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_LATCHED_CLR (at 0xa314)"
      tindex a:0xfc4cfa00 %l 0x80a3140 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_EN_SET (at 0xa315)"
      tindex a:0xfc4cfa00 %l 0x80a3150 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_EN_CLR (at 0xa316)"
      tindex a:0xfc4cfa00 %l 0x80a3160 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_LATCHED_STS (at 0xa318)"
      tindex a:0xfc4cfa00 %l 0x80a3180 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_PENDING_STS (at 0xa319)"
      tindex a:0xfc4cfa00 %l 0x80a3190 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_MID_SEL (at 0xa31a)"
      tindex a:0xfc4cfa00 %l 0x80a31a0 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_PRIORITY (at 0xa31b)"
      tindex a:0xfc4cfa00 %l 0x80a31b0 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_MODE_CTL (at 0xa340)"
      tindex a:0xfc4cfa00 %l 0x80a3400 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_VIN_CTL (at 0xa341)"
      tindex a:0xfc4cfa00 %l 0x80a3410 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_PULL_CTL (at 0xa342)"
      tindex a:0xfc4cfa00 %l 0x80a3420 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_IN_CTL (at 0xa343)"
      tindex a:0xfc4cfa00 %l 0x80a3430 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_EN_CTL (at 0xa346)"
      tindex a:0xfc4cfa00 %l 0x80a3460 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_ANA_OUT_CTL (at 0xa348)"
      tindex a:0xfc4cfa00 %l 0x80a3480 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_ANA_IN_CTL (at 0xa34a)"
      tindex a:0xfc4cfa00 %l 0x80a34a0 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_SINK_CTL (at 0xa34c)"
      tindex a:0xfc4cfa00 %l 0x80a34c0 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_SEC_ACCESS (at 0xa3d0)"
      tindex a:0xfc4cfa00 %l 0x80a3d00 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
      tindex a:0xfc4cfa00 %l 0x80a3d80 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
      tindex a:0xfc4cfa00 %l 0x80a3d90 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
      tindex a:0xfc4cfa00 %l 0x80a3da0 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
      tindex a:0xfc4cfa00 %l 0x80a3db0 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP5"
  tree "MPP5"
    tree "MPP5_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_REVISION1 (at 0xa400)"
      tindex a:0xfc4cfa00 %l 0x80a4000 0xa4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP5_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_REVISION2 (at 0xa401)"
      tindex a:0xfc4cfa00 %l 0x80a4010 0xa4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP5_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_REVISION3 (at 0xa402)"
      tindex a:0xfc4cfa00 %l 0x80a4020 0xa4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP5_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_REVISION4 (at 0xa403)"
      tindex a:0xfc4cfa00 %l 0x80a4030 0xa4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP5_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_TYPE (at 0xa404)"
      tindex a:0xfc4cfa00 %l 0x80a4040 0xa4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP5_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_SUBTYPE (at 0xa405)"
      tindex a:0xfc4cfa00 %l 0x80a4050 0xa4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP5_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_STATUS1 (at 0xa408)"
      tindex a:0xfc4cfa00 %l 0x80a4080 0xa4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP5_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_RT_STS (at 0xa410)"
      tindex a:0xfc4cfa00 %l 0x80a4100 0xa4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP5_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_SET_TYPE (at 0xa411)"
      tindex a:0xfc4cfa00 %l 0x80a4110 0xa4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP5_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_POLARITY_HIGH (at 0xa412)"
      tindex a:0xfc4cfa00 %l 0x80a4120 0xa4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_POLARITY_LOW (at 0xa413)"
      tindex a:0xfc4cfa00 %l 0x80a4130 0xa4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_LATCHED_CLR (at 0xa414)"
      tindex a:0xfc4cfa00 %l 0x80a4140 0xa4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP5_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_EN_SET (at 0xa415)"
      tindex a:0xfc4cfa00 %l 0x80a4150 0xa4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_EN_CLR (at 0xa416)"
      tindex a:0xfc4cfa00 %l 0x80a4160 0xa4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_LATCHED_STS (at 0xa418)"
      tindex a:0xfc4cfa00 %l 0x80a4180 0xa4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP5_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_PENDING_STS (at 0xa419)"
      tindex a:0xfc4cfa00 %l 0x80a4190 0xa4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP5_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_MID_SEL (at 0xa41a)"
      tindex a:0xfc4cfa00 %l 0x80a41a0 0xa41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP5_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_INT_PRIORITY (at 0xa41b)"
      tindex a:0xfc4cfa00 %l 0x80a41b0 0xa41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP5_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_MODE_CTL (at 0xa440)"
      tindex a:0xfc4cfa00 %l 0x80a4400 0xa4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP5_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_DIG_VIN_CTL (at 0xa441)"
      tindex a:0xfc4cfa00 %l 0x80a4410 0xa4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_DIG_PULL_CTL (at 0xa442)"
      tindex a:0xfc4cfa00 %l 0x80a4420 0xa4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_DIG_IN_CTL (at 0xa443)"
      tindex a:0xfc4cfa00 %l 0x80a4430 0xa4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP5_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_EN_CTL (at 0xa446)"
      tindex a:0xfc4cfa00 %l 0x80a4460 0xa4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP5_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_ANA_OUT_CTL (at 0xa448)"
      tindex a:0xfc4cfa00 %l 0x80a4480 0xa4480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_ANA_IN_CTL (at 0xa44a)"
      tindex a:0xfc4cfa00 %l 0x80a44a0 0xa44a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_SINK_CTL (at 0xa44c)"
      tindex a:0xfc4cfa00 %l 0x80a44c0 0xa44c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP5_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_SEC_ACCESS (at 0xa4d0)"
      tindex a:0xfc4cfa00 %l 0x80a4d00 0xa4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP5_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_RESET_CTL1 (at 0xa4d8)"
      tindex a:0xfc4cfa00 %l 0x80a4d80 0xa4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_RESET_CTL2 (at 0xa4d9)"
      tindex a:0xfc4cfa00 %l 0x80a4d90 0xa4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_RESET_CTL3 (at 0xa4da)"
      tindex a:0xfc4cfa00 %l 0x80a4da0 0xa4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP5_PERPH_RESET_CTL4 (at 0xa4db)"
      tindex a:0xfc4cfa00 %l 0x80a4db0 0xa4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP6"
  tree "MPP6"
    tree "MPP6_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_REVISION1 (at 0xa500)"
      tindex a:0xfc4cfa00 %l 0x80a5000 0xa5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP6_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_REVISION2 (at 0xa501)"
      tindex a:0xfc4cfa00 %l 0x80a5010 0xa5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP6_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_REVISION3 (at 0xa502)"
      tindex a:0xfc4cfa00 %l 0x80a5020 0xa5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP6_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_REVISION4 (at 0xa503)"
      tindex a:0xfc4cfa00 %l 0x80a5030 0xa5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP6_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_TYPE (at 0xa504)"
      tindex a:0xfc4cfa00 %l 0x80a5040 0xa5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP6_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_SUBTYPE (at 0xa505)"
      tindex a:0xfc4cfa00 %l 0x80a5050 0xa5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP6_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_STATUS1 (at 0xa508)"
      tindex a:0xfc4cfa00 %l 0x80a5080 0xa5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP6_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_RT_STS (at 0xa510)"
      tindex a:0xfc4cfa00 %l 0x80a5100 0xa5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP6_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_SET_TYPE (at 0xa511)"
      tindex a:0xfc4cfa00 %l 0x80a5110 0xa5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP6_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_POLARITY_HIGH (at 0xa512)"
      tindex a:0xfc4cfa00 %l 0x80a5120 0xa5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_POLARITY_LOW (at 0xa513)"
      tindex a:0xfc4cfa00 %l 0x80a5130 0xa5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_LATCHED_CLR (at 0xa514)"
      tindex a:0xfc4cfa00 %l 0x80a5140 0xa5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP6_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_EN_SET (at 0xa515)"
      tindex a:0xfc4cfa00 %l 0x80a5150 0xa5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_EN_CLR (at 0xa516)"
      tindex a:0xfc4cfa00 %l 0x80a5160 0xa5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_LATCHED_STS (at 0xa518)"
      tindex a:0xfc4cfa00 %l 0x80a5180 0xa5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP6_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_PENDING_STS (at 0xa519)"
      tindex a:0xfc4cfa00 %l 0x80a5190 0xa5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP6_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_MID_SEL (at 0xa51a)"
      tindex a:0xfc4cfa00 %l 0x80a51a0 0xa51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP6_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_INT_PRIORITY (at 0xa51b)"
      tindex a:0xfc4cfa00 %l 0x80a51b0 0xa51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP6_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_MODE_CTL (at 0xa540)"
      tindex a:0xfc4cfa00 %l 0x80a5400 0xa5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP6_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_DIG_VIN_CTL (at 0xa541)"
      tindex a:0xfc4cfa00 %l 0x80a5410 0xa5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_DIG_PULL_CTL (at 0xa542)"
      tindex a:0xfc4cfa00 %l 0x80a5420 0xa5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_DIG_IN_CTL (at 0xa543)"
      tindex a:0xfc4cfa00 %l 0x80a5430 0xa5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP6_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_EN_CTL (at 0xa546)"
      tindex a:0xfc4cfa00 %l 0x80a5460 0xa5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP6_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_ANA_OUT_CTL (at 0xa548)"
      tindex a:0xfc4cfa00 %l 0x80a5480 0xa5480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_ANA_IN_CTL (at 0xa54a)"
      tindex a:0xfc4cfa00 %l 0x80a54a0 0xa54a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_SINK_CTL (at 0xa54c)"
      tindex a:0xfc4cfa00 %l 0x80a54c0 0xa54c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP6_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_SEC_ACCESS (at 0xa5d0)"
      tindex a:0xfc4cfa00 %l 0x80a5d00 0xa5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP6_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_RESET_CTL1 (at 0xa5d8)"
      tindex a:0xfc4cfa00 %l 0x80a5d80 0xa5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_RESET_CTL2 (at 0xa5d9)"
      tindex a:0xfc4cfa00 %l 0x80a5d90 0xa5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_RESET_CTL3 (at 0xa5da)"
      tindex a:0xfc4cfa00 %l 0x80a5da0 0xa5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP6_PERPH_RESET_CTL4 (at 0xa5db)"
      tindex a:0xfc4cfa00 %l 0x80a5db0 0xa5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION1 (at 0x7100)"
      tindex a:0xfc4cfa00 %l 0x8071000 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION2 (at 0x7101)"
      tindex a:0xfc4cfa00 %l 0x8071010 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION3 (at 0x7102)"
      tindex a:0xfc4cfa00 %l 0x8071020 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION4 (at 0x7103)"
      tindex a:0xfc4cfa00 %l 0x8071030 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
      tindex a:0xfc4cfa00 %l 0x8071040 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
      tindex a:0xfc4cfa00 %l 0x8071050 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_STATUS0 (at 0x7108)"
      tindex a:0xfc4cfa00 %l 0x8071080 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_STATUS1 (at 0x7109)"
      tindex a:0xfc4cfa00 %l 0x8071090 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
      tindex a:0xfc4cfa00 %l 0x8071100 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
      tindex a:0xfc4cfa00 %l 0x8071110 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
      tindex a:0xfc4cfa00 %l 0x8071120 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
      tindex a:0xfc4cfa00 %l 0x8071130 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
      tindex a:0xfc4cfa00 %l 0x8071140 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
      tindex a:0xfc4cfa00 %l 0x8071150 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
      tindex a:0xfc4cfa00 %l 0x8071160 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
      tindex a:0xfc4cfa00 %l 0x8071180 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
      tindex a:0xfc4cfa00 %l 0x8071190 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
      tindex a:0xfc4cfa00 %l 0x80711a0 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
      tindex a:0xfc4cfa00 %l 0x80711b0 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
      tindex a:0xfc4cfa00 %l 0x8071400 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
      tindex a:0xfc4cfa00 %l 0x8071420 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_EN_CTL (at 0x7146)"
      tindex a:0xfc4cfa00 %l 0x8071460 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
      tindex a:0xfc4cfa00 %l 0x8071d00 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
      tindex a:0xfc4cfa00 %l 0x8071d80 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
      tindex a:0xfc4cfa00 %l 0x8071d90 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
      tindex a:0xfc4cfa00 %l 0x8071da0 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
      tindex a:0xfc4cfa00 %l 0x8071db0 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
      tindex a:0xfc4cfa00 %l 0x8071e00 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
      tindex a:0xfc4cfa00 %l 0x8071e10 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION1 (at 0x7200)"
      tindex a:0xfc4cfa00 %l 0x8072000 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION2 (at 0x7201)"
      tindex a:0xfc4cfa00 %l 0x8072010 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION3 (at 0x7202)"
      tindex a:0xfc4cfa00 %l 0x8072020 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION4 (at 0x7203)"
      tindex a:0xfc4cfa00 %l 0x8072030 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
      tindex a:0xfc4cfa00 %l 0x8072040 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
      tindex a:0xfc4cfa00 %l 0x8072050 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_STATUS0 (at 0x7208)"
      tindex a:0xfc4cfa00 %l 0x8072080 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_STATUS1 (at 0x7209)"
      tindex a:0xfc4cfa00 %l 0x8072090 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
      tindex a:0xfc4cfa00 %l 0x8072100 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
      tindex a:0xfc4cfa00 %l 0x8072110 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
      tindex a:0xfc4cfa00 %l 0x8072120 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
      tindex a:0xfc4cfa00 %l 0x8072130 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
      tindex a:0xfc4cfa00 %l 0x8072140 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
      tindex a:0xfc4cfa00 %l 0x8072150 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
      tindex a:0xfc4cfa00 %l 0x8072160 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
      tindex a:0xfc4cfa00 %l 0x8072180 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
      tindex a:0xfc4cfa00 %l 0x8072190 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
      tindex a:0xfc4cfa00 %l 0x80721a0 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
      tindex a:0xfc4cfa00 %l 0x80721b0 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
      tindex a:0xfc4cfa00 %l 0x8072400 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
      tindex a:0xfc4cfa00 %l 0x8072420 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_EN_CTL (at 0x7246)"
      tindex a:0xfc4cfa00 %l 0x8072460 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
      tindex a:0xfc4cfa00 %l 0x8072d00 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
      tindex a:0xfc4cfa00 %l 0x8072d80 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
      tindex a:0xfc4cfa00 %l 0x8072d90 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
      tindex a:0xfc4cfa00 %l 0x8072da0 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
      tindex a:0xfc4cfa00 %l 0x8072db0 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
      tindex a:0xfc4cfa00 %l 0x8072e00 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
      tindex a:0xfc4cfa00 %l 0x8072e10 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT10"
  tree "PBS_CLIENT10"
    tree "PBS_CLIENT10_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_REVISION1 (at 0x7b00)"
      tindex a:0xfc4cfa00 %l 0x807b000 0x7b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_REVISION2 (at 0x7b01)"
      tindex a:0xfc4cfa00 %l 0x807b010 0x7b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_REVISION3 (at 0x7b02)"
      tindex a:0xfc4cfa00 %l 0x807b020 0x7b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_REVISION4 (at 0x7b03)"
      tindex a:0xfc4cfa00 %l 0x807b030 0x7b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_TYPE (at 0x7b04)"
      tindex a:0xfc4cfa00 %l 0x807b040 0x7b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT10_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_SUBTYPE (at 0x7b05)"
      tindex a:0xfc4cfa00 %l 0x807b050 0x7b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT10_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_STATUS0 (at 0x7b08)"
      tindex a:0xfc4cfa00 %l 0x807b080 0x7b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_STATUS1 (at 0x7b09)"
      tindex a:0xfc4cfa00 %l 0x807b090 0x7b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT10_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_RT_STS (at 0x7b10)"
      tindex a:0xfc4cfa00 %l 0x807b100 0x7b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT10_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_SET_TYPE (at 0x7b11)"
      tindex a:0xfc4cfa00 %l 0x807b110 0x7b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_POLARITY_HIGH (at 0x7b12)"
      tindex a:0xfc4cfa00 %l 0x807b120 0x7b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_POLARITY_LOW (at 0x7b13)"
      tindex a:0xfc4cfa00 %l 0x807b130 0x7b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_LATCHED_CLR (at 0x7b14)"
      tindex a:0xfc4cfa00 %l 0x807b140 0x7b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_EN_SET (at 0x7b15)"
      tindex a:0xfc4cfa00 %l 0x807b150 0x7b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_EN_CLR (at 0x7b16)"
      tindex a:0xfc4cfa00 %l 0x807b160 0x7b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_LATCHED_STS (at 0x7b18)"
      tindex a:0xfc4cfa00 %l 0x807b180 0x7b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT10_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_PENDING_STS (at 0x7b19)"
      tindex a:0xfc4cfa00 %l 0x807b190 0x7b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT10_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_MID_SEL (at 0x7b1a)"
      tindex a:0xfc4cfa00 %l 0x807b1a0 0x7b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT10_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_PRIORITY (at 0x7b1b)"
      tindex a:0xfc4cfa00 %l 0x807b1b0 0x7b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_TRIG_CFG (at 0x7b40)"
      tindex a:0xfc4cfa00 %l 0x807b400 0x7b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT10_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_TRIG_CTL (at 0x7b42)"
      tindex a:0xfc4cfa00 %l 0x807b420 0x7b420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_EN_CTL (at 0x7b46)"
      tindex a:0xfc4cfa00 %l 0x807b460 0x7b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_SEC_ACCESS (at 0x7bd0)"
      tindex a:0xfc4cfa00 %l 0x807bd00 0x7bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_RESET_CTL1 (at 0x7bd8)"
      tindex a:0xfc4cfa00 %l 0x807bd80 0x7bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_RESET_CTL2 (at 0x7bd9)"
      tindex a:0xfc4cfa00 %l 0x807bd90 0x7bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_RESET_CTL3 (at 0x7bda)"
      tindex a:0xfc4cfa00 %l 0x807bda0 0x7bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_PERPH_RESET_CTL4 (at 0x7bdb)"
      tindex a:0xfc4cfa00 %l 0x807bdb0 0x7bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_TEST1 (at 0x7be0)"
      tindex a:0xfc4cfa00 %l 0x807be00 0x7be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT10_INT_TEST_VAL (at 0x7be1)"
      tindex a:0xfc4cfa00 %l 0x807be10 0x7be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT11"
  tree "PBS_CLIENT11"
    tree "PBS_CLIENT11_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_REVISION1 (at 0x7c00)"
      tindex a:0xfc4cfa00 %l 0x807c000 0x7c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_REVISION2 (at 0x7c01)"
      tindex a:0xfc4cfa00 %l 0x807c010 0x7c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_REVISION3 (at 0x7c02)"
      tindex a:0xfc4cfa00 %l 0x807c020 0x7c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_REVISION4 (at 0x7c03)"
      tindex a:0xfc4cfa00 %l 0x807c030 0x7c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_TYPE (at 0x7c04)"
      tindex a:0xfc4cfa00 %l 0x807c040 0x7c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT11_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_SUBTYPE (at 0x7c05)"
      tindex a:0xfc4cfa00 %l 0x807c050 0x7c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT11_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_STATUS0 (at 0x7c08)"
      tindex a:0xfc4cfa00 %l 0x807c080 0x7c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_STATUS1 (at 0x7c09)"
      tindex a:0xfc4cfa00 %l 0x807c090 0x7c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT11_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_RT_STS (at 0x7c10)"
      tindex a:0xfc4cfa00 %l 0x807c100 0x7c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT11_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_SET_TYPE (at 0x7c11)"
      tindex a:0xfc4cfa00 %l 0x807c110 0x7c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_POLARITY_HIGH (at 0x7c12)"
      tindex a:0xfc4cfa00 %l 0x807c120 0x7c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_POLARITY_LOW (at 0x7c13)"
      tindex a:0xfc4cfa00 %l 0x807c130 0x7c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_LATCHED_CLR (at 0x7c14)"
      tindex a:0xfc4cfa00 %l 0x807c140 0x7c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_EN_SET (at 0x7c15)"
      tindex a:0xfc4cfa00 %l 0x807c150 0x7c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_EN_CLR (at 0x7c16)"
      tindex a:0xfc4cfa00 %l 0x807c160 0x7c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_LATCHED_STS (at 0x7c18)"
      tindex a:0xfc4cfa00 %l 0x807c180 0x7c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT11_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_PENDING_STS (at 0x7c19)"
      tindex a:0xfc4cfa00 %l 0x807c190 0x7c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT11_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_MID_SEL (at 0x7c1a)"
      tindex a:0xfc4cfa00 %l 0x807c1a0 0x7c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT11_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_PRIORITY (at 0x7c1b)"
      tindex a:0xfc4cfa00 %l 0x807c1b0 0x7c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_TRIG_CFG (at 0x7c40)"
      tindex a:0xfc4cfa00 %l 0x807c400 0x7c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT11_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_TRIG_CTL (at 0x7c42)"
      tindex a:0xfc4cfa00 %l 0x807c420 0x7c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_EN_CTL (at 0x7c46)"
      tindex a:0xfc4cfa00 %l 0x807c460 0x7c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_SEC_ACCESS (at 0x7cd0)"
      tindex a:0xfc4cfa00 %l 0x807cd00 0x7cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_RESET_CTL1 (at 0x7cd8)"
      tindex a:0xfc4cfa00 %l 0x807cd80 0x7cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_RESET_CTL2 (at 0x7cd9)"
      tindex a:0xfc4cfa00 %l 0x807cd90 0x7cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_RESET_CTL3 (at 0x7cda)"
      tindex a:0xfc4cfa00 %l 0x807cda0 0x7cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_PERPH_RESET_CTL4 (at 0x7cdb)"
      tindex a:0xfc4cfa00 %l 0x807cdb0 0x7cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_TEST1 (at 0x7ce0)"
      tindex a:0xfc4cfa00 %l 0x807ce00 0x7ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT11_INT_TEST_VAL (at 0x7ce1)"
      tindex a:0xfc4cfa00 %l 0x807ce10 0x7ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT12"
  tree "PBS_CLIENT12"
    tree "PBS_CLIENT12_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_REVISION1 (at 0x7d00)"
      tindex a:0xfc4cfa00 %l 0x807d000 0x7d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_REVISION2 (at 0x7d01)"
      tindex a:0xfc4cfa00 %l 0x807d010 0x7d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_REVISION3 (at 0x7d02)"
      tindex a:0xfc4cfa00 %l 0x807d020 0x7d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_REVISION4 (at 0x7d03)"
      tindex a:0xfc4cfa00 %l 0x807d030 0x7d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_TYPE (at 0x7d04)"
      tindex a:0xfc4cfa00 %l 0x807d040 0x7d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT12_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_SUBTYPE (at 0x7d05)"
      tindex a:0xfc4cfa00 %l 0x807d050 0x7d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT12_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_STATUS0 (at 0x7d08)"
      tindex a:0xfc4cfa00 %l 0x807d080 0x7d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_STATUS1 (at 0x7d09)"
      tindex a:0xfc4cfa00 %l 0x807d090 0x7d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT12_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_RT_STS (at 0x7d10)"
      tindex a:0xfc4cfa00 %l 0x807d100 0x7d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT12_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_SET_TYPE (at 0x7d11)"
      tindex a:0xfc4cfa00 %l 0x807d110 0x7d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_POLARITY_HIGH (at 0x7d12)"
      tindex a:0xfc4cfa00 %l 0x807d120 0x7d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_POLARITY_LOW (at 0x7d13)"
      tindex a:0xfc4cfa00 %l 0x807d130 0x7d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_LATCHED_CLR (at 0x7d14)"
      tindex a:0xfc4cfa00 %l 0x807d140 0x7d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_EN_SET (at 0x7d15)"
      tindex a:0xfc4cfa00 %l 0x807d150 0x7d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_EN_CLR (at 0x7d16)"
      tindex a:0xfc4cfa00 %l 0x807d160 0x7d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_LATCHED_STS (at 0x7d18)"
      tindex a:0xfc4cfa00 %l 0x807d180 0x7d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT12_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_PENDING_STS (at 0x7d19)"
      tindex a:0xfc4cfa00 %l 0x807d190 0x7d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT12_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_MID_SEL (at 0x7d1a)"
      tindex a:0xfc4cfa00 %l 0x807d1a0 0x7d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT12_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_PRIORITY (at 0x7d1b)"
      tindex a:0xfc4cfa00 %l 0x807d1b0 0x7d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_TRIG_CFG (at 0x7d40)"
      tindex a:0xfc4cfa00 %l 0x807d400 0x7d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT12_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_TRIG_CTL (at 0x7d42)"
      tindex a:0xfc4cfa00 %l 0x807d420 0x7d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_EN_CTL (at 0x7d46)"
      tindex a:0xfc4cfa00 %l 0x807d460 0x7d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_SEC_ACCESS (at 0x7dd0)"
      tindex a:0xfc4cfa00 %l 0x807dd00 0x7dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_RESET_CTL1 (at 0x7dd8)"
      tindex a:0xfc4cfa00 %l 0x807dd80 0x7dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_RESET_CTL2 (at 0x7dd9)"
      tindex a:0xfc4cfa00 %l 0x807dd90 0x7dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_RESET_CTL3 (at 0x7dda)"
      tindex a:0xfc4cfa00 %l 0x807dda0 0x7dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_PERPH_RESET_CTL4 (at 0x7ddb)"
      tindex a:0xfc4cfa00 %l 0x807ddb0 0x7ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_TEST1 (at 0x7de0)"
      tindex a:0xfc4cfa00 %l 0x807de00 0x7de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT12_INT_TEST_VAL (at 0x7de1)"
      tindex a:0xfc4cfa00 %l 0x807de10 0x7de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT13"
  tree "PBS_CLIENT13"
    tree "PBS_CLIENT13_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_REVISION1 (at 0x7e00)"
      tindex a:0xfc4cfa00 %l 0x807e000 0x7e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_REVISION2 (at 0x7e01)"
      tindex a:0xfc4cfa00 %l 0x807e010 0x7e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_REVISION3 (at 0x7e02)"
      tindex a:0xfc4cfa00 %l 0x807e020 0x7e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_REVISION4 (at 0x7e03)"
      tindex a:0xfc4cfa00 %l 0x807e030 0x7e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_TYPE (at 0x7e04)"
      tindex a:0xfc4cfa00 %l 0x807e040 0x7e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT13_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_SUBTYPE (at 0x7e05)"
      tindex a:0xfc4cfa00 %l 0x807e050 0x7e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT13_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_STATUS0 (at 0x7e08)"
      tindex a:0xfc4cfa00 %l 0x807e080 0x7e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_STATUS1 (at 0x7e09)"
      tindex a:0xfc4cfa00 %l 0x807e090 0x7e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT13_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_RT_STS (at 0x7e10)"
      tindex a:0xfc4cfa00 %l 0x807e100 0x7e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT13_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_SET_TYPE (at 0x7e11)"
      tindex a:0xfc4cfa00 %l 0x807e110 0x7e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_POLARITY_HIGH (at 0x7e12)"
      tindex a:0xfc4cfa00 %l 0x807e120 0x7e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_POLARITY_LOW (at 0x7e13)"
      tindex a:0xfc4cfa00 %l 0x807e130 0x7e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_LATCHED_CLR (at 0x7e14)"
      tindex a:0xfc4cfa00 %l 0x807e140 0x7e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_EN_SET (at 0x7e15)"
      tindex a:0xfc4cfa00 %l 0x807e150 0x7e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_EN_CLR (at 0x7e16)"
      tindex a:0xfc4cfa00 %l 0x807e160 0x7e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_LATCHED_STS (at 0x7e18)"
      tindex a:0xfc4cfa00 %l 0x807e180 0x7e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT13_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_PENDING_STS (at 0x7e19)"
      tindex a:0xfc4cfa00 %l 0x807e190 0x7e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT13_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_MID_SEL (at 0x7e1a)"
      tindex a:0xfc4cfa00 %l 0x807e1a0 0x7e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT13_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_PRIORITY (at 0x7e1b)"
      tindex a:0xfc4cfa00 %l 0x807e1b0 0x7e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_TRIG_CFG (at 0x7e40)"
      tindex a:0xfc4cfa00 %l 0x807e400 0x7e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT13_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_TRIG_CTL (at 0x7e42)"
      tindex a:0xfc4cfa00 %l 0x807e420 0x7e420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_EN_CTL (at 0x7e46)"
      tindex a:0xfc4cfa00 %l 0x807e460 0x7e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_SEC_ACCESS (at 0x7ed0)"
      tindex a:0xfc4cfa00 %l 0x807ed00 0x7ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_RESET_CTL1 (at 0x7ed8)"
      tindex a:0xfc4cfa00 %l 0x807ed80 0x7ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_RESET_CTL2 (at 0x7ed9)"
      tindex a:0xfc4cfa00 %l 0x807ed90 0x7ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_RESET_CTL3 (at 0x7eda)"
      tindex a:0xfc4cfa00 %l 0x807eda0 0x7eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_PERPH_RESET_CTL4 (at 0x7edb)"
      tindex a:0xfc4cfa00 %l 0x807edb0 0x7edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_TEST1 (at 0x7ee0)"
      tindex a:0xfc4cfa00 %l 0x807ee00 0x7ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT13_INT_TEST_VAL (at 0x7ee1)"
      tindex a:0xfc4cfa00 %l 0x807ee10 0x7ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT14"
  tree "PBS_CLIENT14"
    tree "PBS_CLIENT14_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_REVISION1 (at 0x7f00)"
      tindex a:0xfc4cfa00 %l 0x807f000 0x7f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_REVISION2 (at 0x7f01)"
      tindex a:0xfc4cfa00 %l 0x807f010 0x7f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_REVISION3 (at 0x7f02)"
      tindex a:0xfc4cfa00 %l 0x807f020 0x7f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_REVISION4 (at 0x7f03)"
      tindex a:0xfc4cfa00 %l 0x807f030 0x7f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_TYPE (at 0x7f04)"
      tindex a:0xfc4cfa00 %l 0x807f040 0x7f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT14_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_SUBTYPE (at 0x7f05)"
      tindex a:0xfc4cfa00 %l 0x807f050 0x7f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT14_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_STATUS0 (at 0x7f08)"
      tindex a:0xfc4cfa00 %l 0x807f080 0x7f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_STATUS1 (at 0x7f09)"
      tindex a:0xfc4cfa00 %l 0x807f090 0x7f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT14_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_RT_STS (at 0x7f10)"
      tindex a:0xfc4cfa00 %l 0x807f100 0x7f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT14_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_SET_TYPE (at 0x7f11)"
      tindex a:0xfc4cfa00 %l 0x807f110 0x7f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_POLARITY_HIGH (at 0x7f12)"
      tindex a:0xfc4cfa00 %l 0x807f120 0x7f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_POLARITY_LOW (at 0x7f13)"
      tindex a:0xfc4cfa00 %l 0x807f130 0x7f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_LATCHED_CLR (at 0x7f14)"
      tindex a:0xfc4cfa00 %l 0x807f140 0x7f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_EN_SET (at 0x7f15)"
      tindex a:0xfc4cfa00 %l 0x807f150 0x7f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_EN_CLR (at 0x7f16)"
      tindex a:0xfc4cfa00 %l 0x807f160 0x7f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_LATCHED_STS (at 0x7f18)"
      tindex a:0xfc4cfa00 %l 0x807f180 0x7f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT14_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_PENDING_STS (at 0x7f19)"
      tindex a:0xfc4cfa00 %l 0x807f190 0x7f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT14_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_MID_SEL (at 0x7f1a)"
      tindex a:0xfc4cfa00 %l 0x807f1a0 0x7f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT14_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_PRIORITY (at 0x7f1b)"
      tindex a:0xfc4cfa00 %l 0x807f1b0 0x7f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_TRIG_CFG (at 0x7f40)"
      tindex a:0xfc4cfa00 %l 0x807f400 0x7f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT14_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_TRIG_CTL (at 0x7f42)"
      tindex a:0xfc4cfa00 %l 0x807f420 0x7f420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_EN_CTL (at 0x7f46)"
      tindex a:0xfc4cfa00 %l 0x807f460 0x7f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_SEC_ACCESS (at 0x7fd0)"
      tindex a:0xfc4cfa00 %l 0x807fd00 0x7fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_RESET_CTL1 (at 0x7fd8)"
      tindex a:0xfc4cfa00 %l 0x807fd80 0x7fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_RESET_CTL2 (at 0x7fd9)"
      tindex a:0xfc4cfa00 %l 0x807fd90 0x7fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_RESET_CTL3 (at 0x7fda)"
      tindex a:0xfc4cfa00 %l 0x807fda0 0x7fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_PERPH_RESET_CTL4 (at 0x7fdb)"
      tindex a:0xfc4cfa00 %l 0x807fdb0 0x7fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_TEST1 (at 0x7fe0)"
      tindex a:0xfc4cfa00 %l 0x807fe00 0x7fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT14_INT_TEST_VAL (at 0x7fe1)"
      tindex a:0xfc4cfa00 %l 0x807fe10 0x7fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT15"
  tree "PBS_CLIENT15"
    tree "PBS_CLIENT15_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_REVISION1 (at 0x8000)"
      tindex a:0xfc4cfa00 %l 0x8080000 0x80000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_REVISION2 (at 0x8001)"
      tindex a:0xfc4cfa00 %l 0x8080010 0x80010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_REVISION3 (at 0x8002)"
      tindex a:0xfc4cfa00 %l 0x8080020 0x80020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_REVISION4 (at 0x8003)"
      tindex a:0xfc4cfa00 %l 0x8080030 0x80030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_TYPE (at 0x8004)"
      tindex a:0xfc4cfa00 %l 0x8080040 0x80040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT15_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_SUBTYPE (at 0x8005)"
      tindex a:0xfc4cfa00 %l 0x8080050 0x80050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT15_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_STATUS0 (at 0x8008)"
      tindex a:0xfc4cfa00 %l 0x8080080 0x80080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_STATUS1 (at 0x8009)"
      tindex a:0xfc4cfa00 %l 0x8080090 0x80090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT15_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_RT_STS (at 0x8010)"
      tindex a:0xfc4cfa00 %l 0x8080100 0x80100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT15_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_SET_TYPE (at 0x8011)"
      tindex a:0xfc4cfa00 %l 0x8080110 0x80110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_POLARITY_HIGH (at 0x8012)"
      tindex a:0xfc4cfa00 %l 0x8080120 0x80120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_POLARITY_LOW (at 0x8013)"
      tindex a:0xfc4cfa00 %l 0x8080130 0x80130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_LATCHED_CLR (at 0x8014)"
      tindex a:0xfc4cfa00 %l 0x8080140 0x80140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_EN_SET (at 0x8015)"
      tindex a:0xfc4cfa00 %l 0x8080150 0x80150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_EN_CLR (at 0x8016)"
      tindex a:0xfc4cfa00 %l 0x8080160 0x80160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_LATCHED_STS (at 0x8018)"
      tindex a:0xfc4cfa00 %l 0x8080180 0x80180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT15_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_PENDING_STS (at 0x8019)"
      tindex a:0xfc4cfa00 %l 0x8080190 0x80190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT15_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_MID_SEL (at 0x801a)"
      tindex a:0xfc4cfa00 %l 0x80801a0 0x801a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT15_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_PRIORITY (at 0x801b)"
      tindex a:0xfc4cfa00 %l 0x80801b0 0x801b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_TRIG_CFG (at 0x8040)"
      tindex a:0xfc4cfa00 %l 0x8080400 0x80400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT15_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_TRIG_CTL (at 0x8042)"
      tindex a:0xfc4cfa00 %l 0x8080420 0x80420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_EN_CTL (at 0x8046)"
      tindex a:0xfc4cfa00 %l 0x8080460 0x80460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_SEC_ACCESS (at 0x80d0)"
      tindex a:0xfc4cfa00 %l 0x8080d00 0x80d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_RESET_CTL1 (at 0x80d8)"
      tindex a:0xfc4cfa00 %l 0x8080d80 0x80d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_RESET_CTL2 (at 0x80d9)"
      tindex a:0xfc4cfa00 %l 0x8080d90 0x80d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_RESET_CTL3 (at 0x80da)"
      tindex a:0xfc4cfa00 %l 0x8080da0 0x80da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_PERPH_RESET_CTL4 (at 0x80db)"
      tindex a:0xfc4cfa00 %l 0x8080db0 0x80db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_TEST1 (at 0x80e0)"
      tindex a:0xfc4cfa00 %l 0x8080e00 0x80e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT15_INT_TEST_VAL (at 0x80e1)"
      tindex a:0xfc4cfa00 %l 0x8080e10 0x80e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION1 (at 0x7300)"
      tindex a:0xfc4cfa00 %l 0x8073000 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION2 (at 0x7301)"
      tindex a:0xfc4cfa00 %l 0x8073010 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION3 (at 0x7302)"
      tindex a:0xfc4cfa00 %l 0x8073020 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION4 (at 0x7303)"
      tindex a:0xfc4cfa00 %l 0x8073030 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
      tindex a:0xfc4cfa00 %l 0x8073040 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
      tindex a:0xfc4cfa00 %l 0x8073050 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_STATUS0 (at 0x7308)"
      tindex a:0xfc4cfa00 %l 0x8073080 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_STATUS1 (at 0x7309)"
      tindex a:0xfc4cfa00 %l 0x8073090 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
      tindex a:0xfc4cfa00 %l 0x8073100 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
      tindex a:0xfc4cfa00 %l 0x8073110 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
      tindex a:0xfc4cfa00 %l 0x8073120 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
      tindex a:0xfc4cfa00 %l 0x8073130 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
      tindex a:0xfc4cfa00 %l 0x8073140 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
      tindex a:0xfc4cfa00 %l 0x8073150 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
      tindex a:0xfc4cfa00 %l 0x8073160 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
      tindex a:0xfc4cfa00 %l 0x8073180 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
      tindex a:0xfc4cfa00 %l 0x8073190 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
      tindex a:0xfc4cfa00 %l 0x80731a0 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
      tindex a:0xfc4cfa00 %l 0x80731b0 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
      tindex a:0xfc4cfa00 %l 0x8073400 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
      tindex a:0xfc4cfa00 %l 0x8073420 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_EN_CTL (at 0x7346)"
      tindex a:0xfc4cfa00 %l 0x8073460 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
      tindex a:0xfc4cfa00 %l 0x8073d00 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
      tindex a:0xfc4cfa00 %l 0x8073d80 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
      tindex a:0xfc4cfa00 %l 0x8073d90 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
      tindex a:0xfc4cfa00 %l 0x8073da0 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
      tindex a:0xfc4cfa00 %l 0x8073db0 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
      tindex a:0xfc4cfa00 %l 0x8073e00 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
      tindex a:0xfc4cfa00 %l 0x8073e10 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION1 (at 0x7400)"
      tindex a:0xfc4cfa00 %l 0x8074000 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION2 (at 0x7401)"
      tindex a:0xfc4cfa00 %l 0x8074010 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION3 (at 0x7402)"
      tindex a:0xfc4cfa00 %l 0x8074020 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION4 (at 0x7403)"
      tindex a:0xfc4cfa00 %l 0x8074030 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
      tindex a:0xfc4cfa00 %l 0x8074040 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
      tindex a:0xfc4cfa00 %l 0x8074050 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_STATUS0 (at 0x7408)"
      tindex a:0xfc4cfa00 %l 0x8074080 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_STATUS1 (at 0x7409)"
      tindex a:0xfc4cfa00 %l 0x8074090 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
      tindex a:0xfc4cfa00 %l 0x8074100 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
      tindex a:0xfc4cfa00 %l 0x8074110 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
      tindex a:0xfc4cfa00 %l 0x8074120 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
      tindex a:0xfc4cfa00 %l 0x8074130 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
      tindex a:0xfc4cfa00 %l 0x8074140 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
      tindex a:0xfc4cfa00 %l 0x8074150 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
      tindex a:0xfc4cfa00 %l 0x8074160 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
      tindex a:0xfc4cfa00 %l 0x8074180 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
      tindex a:0xfc4cfa00 %l 0x8074190 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
      tindex a:0xfc4cfa00 %l 0x80741a0 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
      tindex a:0xfc4cfa00 %l 0x80741b0 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
      tindex a:0xfc4cfa00 %l 0x8074400 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
      tindex a:0xfc4cfa00 %l 0x8074420 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_EN_CTL (at 0x7446)"
      tindex a:0xfc4cfa00 %l 0x8074460 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
      tindex a:0xfc4cfa00 %l 0x8074d00 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
      tindex a:0xfc4cfa00 %l 0x8074d80 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
      tindex a:0xfc4cfa00 %l 0x8074d90 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
      tindex a:0xfc4cfa00 %l 0x8074da0 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
      tindex a:0xfc4cfa00 %l 0x8074db0 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
      tindex a:0xfc4cfa00 %l 0x8074e00 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
      tindex a:0xfc4cfa00 %l 0x8074e10 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION1 (at 0x7500)"
      tindex a:0xfc4cfa00 %l 0x8075000 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION2 (at 0x7501)"
      tindex a:0xfc4cfa00 %l 0x8075010 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION3 (at 0x7502)"
      tindex a:0xfc4cfa00 %l 0x8075020 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION4 (at 0x7503)"
      tindex a:0xfc4cfa00 %l 0x8075030 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
      tindex a:0xfc4cfa00 %l 0x8075040 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
      tindex a:0xfc4cfa00 %l 0x8075050 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_STATUS0 (at 0x7508)"
      tindex a:0xfc4cfa00 %l 0x8075080 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_STATUS1 (at 0x7509)"
      tindex a:0xfc4cfa00 %l 0x8075090 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
      tindex a:0xfc4cfa00 %l 0x8075100 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
      tindex a:0xfc4cfa00 %l 0x8075110 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
      tindex a:0xfc4cfa00 %l 0x8075120 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
      tindex a:0xfc4cfa00 %l 0x8075130 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
      tindex a:0xfc4cfa00 %l 0x8075140 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
      tindex a:0xfc4cfa00 %l 0x8075150 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
      tindex a:0xfc4cfa00 %l 0x8075160 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
      tindex a:0xfc4cfa00 %l 0x8075180 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
      tindex a:0xfc4cfa00 %l 0x8075190 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
      tindex a:0xfc4cfa00 %l 0x80751a0 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
      tindex a:0xfc4cfa00 %l 0x80751b0 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
      tindex a:0xfc4cfa00 %l 0x8075400 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
      tindex a:0xfc4cfa00 %l 0x8075420 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_EN_CTL (at 0x7546)"
      tindex a:0xfc4cfa00 %l 0x8075460 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
      tindex a:0xfc4cfa00 %l 0x8075d00 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
      tindex a:0xfc4cfa00 %l 0x8075d80 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
      tindex a:0xfc4cfa00 %l 0x8075d90 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
      tindex a:0xfc4cfa00 %l 0x8075da0 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
      tindex a:0xfc4cfa00 %l 0x8075db0 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
      tindex a:0xfc4cfa00 %l 0x8075e00 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
      tindex a:0xfc4cfa00 %l 0x8075e10 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION1 (at 0x7600)"
      tindex a:0xfc4cfa00 %l 0x8076000 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION2 (at 0x7601)"
      tindex a:0xfc4cfa00 %l 0x8076010 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION3 (at 0x7602)"
      tindex a:0xfc4cfa00 %l 0x8076020 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION4 (at 0x7603)"
      tindex a:0xfc4cfa00 %l 0x8076030 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
      tindex a:0xfc4cfa00 %l 0x8076040 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
      tindex a:0xfc4cfa00 %l 0x8076050 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_STATUS0 (at 0x7608)"
      tindex a:0xfc4cfa00 %l 0x8076080 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_STATUS1 (at 0x7609)"
      tindex a:0xfc4cfa00 %l 0x8076090 0x76090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
      tindex a:0xfc4cfa00 %l 0x8076100 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
      tindex a:0xfc4cfa00 %l 0x8076110 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
      tindex a:0xfc4cfa00 %l 0x8076120 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
      tindex a:0xfc4cfa00 %l 0x8076130 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
      tindex a:0xfc4cfa00 %l 0x8076140 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
      tindex a:0xfc4cfa00 %l 0x8076150 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
      tindex a:0xfc4cfa00 %l 0x8076160 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
      tindex a:0xfc4cfa00 %l 0x8076180 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
      tindex a:0xfc4cfa00 %l 0x8076190 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
      tindex a:0xfc4cfa00 %l 0x80761a0 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
      tindex a:0xfc4cfa00 %l 0x80761b0 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
      tindex a:0xfc4cfa00 %l 0x8076400 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
      tindex a:0xfc4cfa00 %l 0x8076420 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_EN_CTL (at 0x7646)"
      tindex a:0xfc4cfa00 %l 0x8076460 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
      tindex a:0xfc4cfa00 %l 0x8076d00 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
      tindex a:0xfc4cfa00 %l 0x8076d80 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
      tindex a:0xfc4cfa00 %l 0x8076d90 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
      tindex a:0xfc4cfa00 %l 0x8076da0 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
      tindex a:0xfc4cfa00 %l 0x8076db0 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
      tindex a:0xfc4cfa00 %l 0x8076e00 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
      tindex a:0xfc4cfa00 %l 0x8076e10 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION1 (at 0x7700)"
      tindex a:0xfc4cfa00 %l 0x8077000 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION2 (at 0x7701)"
      tindex a:0xfc4cfa00 %l 0x8077010 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION3 (at 0x7702)"
      tindex a:0xfc4cfa00 %l 0x8077020 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION4 (at 0x7703)"
      tindex a:0xfc4cfa00 %l 0x8077030 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
      tindex a:0xfc4cfa00 %l 0x8077040 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
      tindex a:0xfc4cfa00 %l 0x8077050 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_STATUS0 (at 0x7708)"
      tindex a:0xfc4cfa00 %l 0x8077080 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_STATUS1 (at 0x7709)"
      tindex a:0xfc4cfa00 %l 0x8077090 0x77090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
      tindex a:0xfc4cfa00 %l 0x8077100 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
      tindex a:0xfc4cfa00 %l 0x8077110 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
      tindex a:0xfc4cfa00 %l 0x8077120 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
      tindex a:0xfc4cfa00 %l 0x8077130 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
      tindex a:0xfc4cfa00 %l 0x8077140 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
      tindex a:0xfc4cfa00 %l 0x8077150 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
      tindex a:0xfc4cfa00 %l 0x8077160 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
      tindex a:0xfc4cfa00 %l 0x8077180 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
      tindex a:0xfc4cfa00 %l 0x8077190 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
      tindex a:0xfc4cfa00 %l 0x80771a0 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
      tindex a:0xfc4cfa00 %l 0x80771b0 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
      tindex a:0xfc4cfa00 %l 0x8077400 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
      tindex a:0xfc4cfa00 %l 0x8077420 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_EN_CTL (at 0x7746)"
      tindex a:0xfc4cfa00 %l 0x8077460 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
      tindex a:0xfc4cfa00 %l 0x8077d00 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
      tindex a:0xfc4cfa00 %l 0x8077d80 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
      tindex a:0xfc4cfa00 %l 0x8077d90 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
      tindex a:0xfc4cfa00 %l 0x8077da0 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
      tindex a:0xfc4cfa00 %l 0x8077db0 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
      tindex a:0xfc4cfa00 %l 0x8077e00 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
      tindex a:0xfc4cfa00 %l 0x8077e10 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION1 (at 0x7800)"
      tindex a:0xfc4cfa00 %l 0x8078000 0x78000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION2 (at 0x7801)"
      tindex a:0xfc4cfa00 %l 0x8078010 0x78010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION3 (at 0x7802)"
      tindex a:0xfc4cfa00 %l 0x8078020 0x78020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION4 (at 0x7803)"
      tindex a:0xfc4cfa00 %l 0x8078030 0x78030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
      tindex a:0xfc4cfa00 %l 0x8078040 0x78040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
      tindex a:0xfc4cfa00 %l 0x8078050 0x78050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_STATUS0 (at 0x7808)"
      tindex a:0xfc4cfa00 %l 0x8078080 0x78080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_STATUS1 (at 0x7809)"
      tindex a:0xfc4cfa00 %l 0x8078090 0x78090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
      tindex a:0xfc4cfa00 %l 0x8078100 0x78100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
      tindex a:0xfc4cfa00 %l 0x8078110 0x78110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
      tindex a:0xfc4cfa00 %l 0x8078120 0x78120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
      tindex a:0xfc4cfa00 %l 0x8078130 0x78130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
      tindex a:0xfc4cfa00 %l 0x8078140 0x78140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
      tindex a:0xfc4cfa00 %l 0x8078150 0x78150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
      tindex a:0xfc4cfa00 %l 0x8078160 0x78160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
      tindex a:0xfc4cfa00 %l 0x8078180 0x78180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
      tindex a:0xfc4cfa00 %l 0x8078190 0x78190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
      tindex a:0xfc4cfa00 %l 0x80781a0 0x781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
      tindex a:0xfc4cfa00 %l 0x80781b0 0x781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
      tindex a:0xfc4cfa00 %l 0x8078400 0x78400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
      tindex a:0xfc4cfa00 %l 0x8078420 0x78420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_EN_CTL (at 0x7846)"
      tindex a:0xfc4cfa00 %l 0x8078460 0x78460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
      tindex a:0xfc4cfa00 %l 0x8078d00 0x78d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
      tindex a:0xfc4cfa00 %l 0x8078d80 0x78d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
      tindex a:0xfc4cfa00 %l 0x8078d90 0x78d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
      tindex a:0xfc4cfa00 %l 0x8078da0 0x78da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
      tindex a:0xfc4cfa00 %l 0x8078db0 0x78db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
      tindex a:0xfc4cfa00 %l 0x8078e00 0x78e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
      tindex a:0xfc4cfa00 %l 0x8078e10 0x78e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_REVISION1 (at 0x7900)"
      tindex a:0xfc4cfa00 %l 0x8079000 0x79000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_REVISION2 (at 0x7901)"
      tindex a:0xfc4cfa00 %l 0x8079010 0x79010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_REVISION3 (at 0x7902)"
      tindex a:0xfc4cfa00 %l 0x8079020 0x79020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_REVISION4 (at 0x7903)"
      tindex a:0xfc4cfa00 %l 0x8079030 0x79030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
      tindex a:0xfc4cfa00 %l 0x8079040 0x79040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
      tindex a:0xfc4cfa00 %l 0x8079050 0x79050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_STATUS0 (at 0x7908)"
      tindex a:0xfc4cfa00 %l 0x8079080 0x79080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_STATUS1 (at 0x7909)"
      tindex a:0xfc4cfa00 %l 0x8079090 0x79090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
      tindex a:0xfc4cfa00 %l 0x8079100 0x79100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
      tindex a:0xfc4cfa00 %l 0x8079110 0x79110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
      tindex a:0xfc4cfa00 %l 0x8079120 0x79120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
      tindex a:0xfc4cfa00 %l 0x8079130 0x79130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
      tindex a:0xfc4cfa00 %l 0x8079140 0x79140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
      tindex a:0xfc4cfa00 %l 0x8079150 0x79150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
      tindex a:0xfc4cfa00 %l 0x8079160 0x79160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
      tindex a:0xfc4cfa00 %l 0x8079180 0x79180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
      tindex a:0xfc4cfa00 %l 0x8079190 0x79190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
      tindex a:0xfc4cfa00 %l 0x80791a0 0x791a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
      tindex a:0xfc4cfa00 %l 0x80791b0 0x791b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
      tindex a:0xfc4cfa00 %l 0x8079400 0x79400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
      tindex a:0xfc4cfa00 %l 0x8079420 0x79420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_EN_CTL (at 0x7946)"
      tindex a:0xfc4cfa00 %l 0x8079460 0x79460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
      tindex a:0xfc4cfa00 %l 0x8079d00 0x79d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
      tindex a:0xfc4cfa00 %l 0x8079d80 0x79d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
      tindex a:0xfc4cfa00 %l 0x8079d90 0x79d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
      tindex a:0xfc4cfa00 %l 0x8079da0 0x79da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
      tindex a:0xfc4cfa00 %l 0x8079db0 0x79db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
      tindex a:0xfc4cfa00 %l 0x8079e00 0x79e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
      tindex a:0xfc4cfa00 %l 0x8079e10 0x79e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT9"
  tree "PBS_CLIENT9"
    tree "PBS_CLIENT9_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_REVISION1 (at 0x7a00)"
      tindex a:0xfc4cfa00 %l 0x807a000 0x7a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_REVISION2 (at 0x7a01)"
      tindex a:0xfc4cfa00 %l 0x807a010 0x7a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_REVISION3 (at 0x7a02)"
      tindex a:0xfc4cfa00 %l 0x807a020 0x7a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_REVISION4 (at 0x7a03)"
      tindex a:0xfc4cfa00 %l 0x807a030 0x7a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_TYPE (at 0x7a04)"
      tindex a:0xfc4cfa00 %l 0x807a040 0x7a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT9_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_SUBTYPE (at 0x7a05)"
      tindex a:0xfc4cfa00 %l 0x807a050 0x7a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT9_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_STATUS0 (at 0x7a08)"
      tindex a:0xfc4cfa00 %l 0x807a080 0x7a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_STATUS1 (at 0x7a09)"
      tindex a:0xfc4cfa00 %l 0x807a090 0x7a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT9_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_RT_STS (at 0x7a10)"
      tindex a:0xfc4cfa00 %l 0x807a100 0x7a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT9_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_SET_TYPE (at 0x7a11)"
      tindex a:0xfc4cfa00 %l 0x807a110 0x7a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_POLARITY_HIGH (at 0x7a12)"
      tindex a:0xfc4cfa00 %l 0x807a120 0x7a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_POLARITY_LOW (at 0x7a13)"
      tindex a:0xfc4cfa00 %l 0x807a130 0x7a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_LATCHED_CLR (at 0x7a14)"
      tindex a:0xfc4cfa00 %l 0x807a140 0x7a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_EN_SET (at 0x7a15)"
      tindex a:0xfc4cfa00 %l 0x807a150 0x7a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_EN_CLR (at 0x7a16)"
      tindex a:0xfc4cfa00 %l 0x807a160 0x7a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_LATCHED_STS (at 0x7a18)"
      tindex a:0xfc4cfa00 %l 0x807a180 0x7a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT9_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_PENDING_STS (at 0x7a19)"
      tindex a:0xfc4cfa00 %l 0x807a190 0x7a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT9_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_MID_SEL (at 0x7a1a)"
      tindex a:0xfc4cfa00 %l 0x807a1a0 0x7a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT9_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_PRIORITY (at 0x7a1b)"
      tindex a:0xfc4cfa00 %l 0x807a1b0 0x7a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_TRIG_CFG (at 0x7a40)"
      tindex a:0xfc4cfa00 %l 0x807a400 0x7a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT9_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_TRIG_CTL (at 0x7a42)"
      tindex a:0xfc4cfa00 %l 0x807a420 0x7a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_EN_CTL (at 0x7a46)"
      tindex a:0xfc4cfa00 %l 0x807a460 0x7a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_SEC_ACCESS (at 0x7ad0)"
      tindex a:0xfc4cfa00 %l 0x807ad00 0x7ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_RESET_CTL1 (at 0x7ad8)"
      tindex a:0xfc4cfa00 %l 0x807ad80 0x7ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_RESET_CTL2 (at 0x7ad9)"
      tindex a:0xfc4cfa00 %l 0x807ad90 0x7ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_RESET_CTL3 (at 0x7ada)"
      tindex a:0xfc4cfa00 %l 0x807ada0 0x7ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_PERPH_RESET_CTL4 (at 0x7adb)"
      tindex a:0xfc4cfa00 %l 0x807adb0 0x7adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_TEST1 (at 0x7ae0)"
      tindex a:0xfc4cfa00 %l 0x807ae00 0x7ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT9_INT_TEST_VAL (at 0x7ae1)"
      tindex a:0xfc4cfa00 %l 0x807ae10 0x7ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION1 (at 0x7000)"
      tindex a:0xfc4cfa00 %l 0x8070000 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION2 (at 0x7001)"
      tindex a:0xfc4cfa00 %l 0x8070010 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION3 (at 0x7002)"
      tindex a:0xfc4cfa00 %l 0x8070020 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION4 (at 0x7003)"
      tindex a:0xfc4cfa00 %l 0x8070030 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_TYPE (at 0x7004)"
      tindex a:0xfc4cfa00 %l 0x8070040 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
      tindex a:0xfc4cfa00 %l 0x8070050 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
      tindex a:0xfc4cfa00 %l 0x8070080 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
      tindex a:0xfc4cfa00 %l 0x8070090 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
      tindex a:0xfc4cfa00 %l 0x80700a0 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
      tindex a:0xfc4cfa00 %l 0x80700b0 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
      tindex a:0xfc4cfa00 %l 0x80700c0 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
      tindex a:0xfc4cfa00 %l 0x80700d0 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
      tindex a:0xfc4cfa00 %l 0x80700e0 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
      tindex a:0xfc4cfa00 %l 0x80700f0 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
      tindex a:0xfc4cfa00 %l 0x8070400 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
      tindex a:0xfc4cfa00 %l 0x8070410 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
      tindex a:0xfc4cfa00 %l 0x8070420 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
      tindex a:0xfc4cfa00 %l 0x8070430 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
      tindex a:0xfc4cfa00 %l 0x8070480 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
      tindex a:0xfc4cfa00 %l 0x8070490 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
      tindex a:0xfc4cfa00 %l 0x80704a0 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
      tindex a:0xfc4cfa00 %l 0x80704b0 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
      tindex a:0xfc4cfa00 %l 0x80704c0 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
      tindex a:0xfc4cfa00 %l 0x80704d0 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
      tindex a:0xfc4cfa00 %l 0x80704e0 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
      tindex a:0xfc4cfa00 %l 0x80704f0 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
      tindex a:0xfc4cfa00 %l 0x8070500 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
      tindex a:0xfc4cfa00 %l 0x8070510 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
      tindex a:0xfc4cfa00 %l 0x8070540 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
      tindex a:0xfc4cfa00 %l 0x8070550 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
      tindex a:0xfc4cfa00 %l 0x8070580 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
      tindex a:0xfc4cfa00 %l 0x8070590 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
      tindex a:0xfc4cfa00 %l 0x80705c0 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
      tindex a:0xfc4cfa00 %l 0x80705d0 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
      tindex a:0xfc4cfa00 %l 0x8070600 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
      tindex a:0xfc4cfa00 %l 0x8070610 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
      tindex a:0xfc4cfa00 %l 0x8070640 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
      tindex a:0xfc4cfa00 %l 0x8070650 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
      tindex a:0xfc4cfa00 %l 0x8070680 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
      tindex a:0xfc4cfa00 %l 0x8070690 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
      tindex a:0xfc4cfa00 %l 0x80706c0 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
      tindex a:0xfc4cfa00 %l 0x80706d0 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
      tindex a:0xfc4cfa00 %l 0x8070700 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
      tindex a:0xfc4cfa00 %l 0x8070710 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
      tindex a:0xfc4cfa00 %l 0x8070740 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
      tindex a:0xfc4cfa00 %l 0x8070750 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
      tindex a:0xfc4cfa00 %l 0x8070780 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
      tindex a:0xfc4cfa00 %l 0x8070790 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
      tindex a:0xfc4cfa00 %l 0x80707c0 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
      tindex a:0xfc4cfa00 %l 0x80707d0 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
      tindex a:0xfc4cfa00 %l 0x8070800 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
      tindex a:0xfc4cfa00 %l 0x8070810 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
      tindex a:0xfc4cfa00 %l 0x8070840 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
      tindex a:0xfc4cfa00 %l 0x8070850 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
      tindex a:0xfc4cfa00 %l 0x8070880 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
      tindex a:0xfc4cfa00 %l 0x8070890 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
      tindex a:0xfc4cfa00 %l 0x80708c0 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
      tindex a:0xfc4cfa00 %l 0x80708d0 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
      tindex a:0xfc4cfa00 %l 0x8070900 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
      tindex a:0xfc4cfa00 %l 0x8070910 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
      tindex a:0xfc4cfa00 %l 0x8070920 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
      tindex a:0xfc4cfa00 %l 0x8070930 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
      tindex a:0xfc4cfa00 %l 0x8070940 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
      tindex a:0xfc4cfa00 %l 0x8070950 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
      tindex a:0xfc4cfa00 %l 0x8070960 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
      tindex a:0xfc4cfa00 %l 0x8070970 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEC_ACCESS (at 0x70d0)"
      tindex a:0xfc4cfa00 %l 0x8070d00 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
      tindex a:0xfc4cfa00 %l 0x8070d90 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
      tindex a:0xfc4cfa00 %l 0x8070da0 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
      tindex a:0xfc4cfa00 %l 0x8070db0 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
      tindex a:0xfc4cfa00 %l 0x8070e00 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
      tindex a:0xfc4cfa00 %l 0x8070e10 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_OTP_CFG1 (at 0x70e2)"
      tindex a:0xfc4cfa00 %l 0x8070e20 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_OTP_CFG2 (at 0x70e3)"
      tindex a:0xfc4cfa00 %l 0x8070e30 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TEST1 (at 0x70e4)"
      tindex a:0xfc4cfa00 %l 0x8070e40 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION1 (at 0x800)"
      tindex a:0xfc4cfa00 %l 0x8008000 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION2 (at 0x801)"
      tindex a:0xfc4cfa00 %l 0x8008010 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION3 (at 0x802)"
      tindex a:0xfc4cfa00 %l 0x8008020 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION4 (at 0x803)"
      tindex a:0xfc4cfa00 %l 0x8008030 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_TYPE (at 0x804)"
      tindex a:0xfc4cfa00 %l 0x8008040 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_SUBTYPE (at 0x805)"
      tindex a:0xfc4cfa00 %l 0x8008050 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_PBL_STATUS (at 0x807)"
      tindex a:0xfc4cfa00 %l 0x8008070 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_REASON1 (at 0x808)"
      tindex a:0xfc4cfa00 %l 0x8008080 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_WARM_RESET_REASON1 (at 0x80a)"
      tindex a:0xfc4cfa00 %l 0x80080a0 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_WARM_RESET_REASON2 (at 0x80b)"
      tindex a:0xfc4cfa00 %l 0x80080b0 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_POFF_REASON1 (at 0x80c)"
      tindex a:0xfc4cfa00 %l 0x80080c0 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_POFF_REASON2 (at 0x80d)"
      tindex a:0xfc4cfa00 %l 0x80080d0 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RESET_REASON1 (at 0x80e)"
      tindex a:0xfc4cfa00 %l 0x80080e0 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RESET_REASON2 (at 0x80f)"
      tindex a:0xfc4cfa00 %l 0x80080f0 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_RT_STS (at 0x810)"
      tindex a:0xfc4cfa00 %l 0x8008100 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_SET_TYPE (at 0x811)"
      tindex a:0xfc4cfa00 %l 0x8008110 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_POLARITY_HIGH (at 0x812)"
      tindex a:0xfc4cfa00 %l 0x8008120 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_POLARITY_LOW (at 0x813)"
      tindex a:0xfc4cfa00 %l 0x8008130 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_LATCHED_CLR (at 0x814)"
      tindex a:0xfc4cfa00 %l 0x8008140 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_EN_SET (at 0x815)"
      tindex a:0xfc4cfa00 %l 0x8008150 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_EN_CLR (at 0x816)"
      tindex a:0xfc4cfa00 %l 0x8008160 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_LATCHED_STS (at 0x818)"
      tindex a:0xfc4cfa00 %l 0x8008180 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_PENDING_STS (at 0x819)"
      tindex a:0xfc4cfa00 %l 0x8008190 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_MID_SEL (at 0x81a)"
      tindex a:0xfc4cfa00 %l 0x80081a0 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_PRIORITY (at 0x81b)"
      tindex a:0xfc4cfa00 %l 0x80081b0 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
      tindex a:0xfc4cfa00 %l 0x8008400 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
      tindex a:0xfc4cfa00 %l 0x8008410 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
      tindex a:0xfc4cfa00 %l 0x8008420 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
      tindex a:0xfc4cfa00 %l 0x8008430 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
      tindex a:0xfc4cfa00 %l 0x8008440 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
      tindex a:0xfc4cfa00 %l 0x8008450 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
      tindex a:0xfc4cfa00 %l 0x8008460 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
      tindex a:0xfc4cfa00 %l 0x8008470 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
      tindex a:0xfc4cfa00 %l 0x8008480 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
      tindex a:0xfc4cfa00 %l 0x8008490 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
      tindex a:0xfc4cfa00 %l 0x80084a0 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
      tindex a:0xfc4cfa00 %l 0x80084b0 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S1_TIMER (at 0x84c)"
      tindex a:0xfc4cfa00 %l 0x80084c0 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S2_TIMER (at 0x84d)"
      tindex a:0xfc4cfa00 %l 0x80084d0 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S2_CTL (at 0x84e)"
      tindex a:0xfc4cfa00 %l 0x80084e0 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
      tindex a:0xfc4cfa00 %l 0x80084f0 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S1_TIMER (at 0x850)"
      tindex a:0xfc4cfa00 %l 0x8008500 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S2_TIMER (at 0x851)"
      tindex a:0xfc4cfa00 %l 0x8008510 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S2_CTL (at 0x852)"
      tindex a:0xfc4cfa00 %l 0x8008520 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S2_CTL2 (at 0x853)"
      tindex a:0xfc4cfa00 %l 0x8008530 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
      tindex a:0xfc4cfa00 %l 0x8008540 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
      tindex a:0xfc4cfa00 %l 0x8008550 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
      tindex a:0xfc4cfa00 %l 0x8008560 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
      tindex a:0xfc4cfa00 %l 0x8008570 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_PET (at 0x858)"
      tindex a:0xfc4cfa00 %l 0x8008580 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PS_HOLD_RESET_CTL (at 0x85a)"
      tindex a:0xfc4cfa00 %l 0x80085a0 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
      tindex a:0xfc4cfa00 %l 0x80085b0 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SW_RESET_S2_CTL (at 0x862)"
      tindex a:0xfc4cfa00 %l 0x8008620 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SW_RESET_S2_CTL2 (at 0x863)"
      tindex a:0xfc4cfa00 %l 0x8008630 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SW_RESET_GO (at 0x864)"
      tindex a:0xfc4cfa00 %l 0x8008640 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_OVERTEMP_RESET_CTL (at 0x866)"
      tindex a:0xfc4cfa00 %l 0x8008660 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
      tindex a:0xfc4cfa00 %l 0x8008670 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TFT_RESET_CTL (at 0x86a)"
      tindex a:0xfc4cfa00 %l 0x80086a0 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TFT_RESET_CTL2 (at 0x86b)"
      tindex a:0xfc4cfa00 %l 0x80086b0 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PULL_CTL (at 0x870)"
      tindex a:0xfc4cfa00 %l 0x8008700 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_DEBOUNCE_CTL (at 0x871)"
      tindex a:0xfc4cfa00 %l 0x8008710 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESET_S3_SRC (at 0x874)"
      tindex a:0xfc4cfa00 %l 0x8008740 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESET_S3_TIMER (at 0x875)"
      tindex a:0xfc4cfa00 %l 0x8008750 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_TRIGGER_EN (at 0x880)"
      tindex a:0xfc4cfa00 %l 0x8008800 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_OPTION_BITS (at 0x882)"
      tindex a:0xfc4cfa00 %l 0x8008820 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_50K_EN                             = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_WATCHDOG_LOCK (at 0x883)"
      tindex a:0xfc4cfa00 %l 0x8008830 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_UVLO (at 0x888)"
      tindex a:0xfc4cfa00 %l 0x8008880 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_AVDD_VPH (at 0x88a)"
      tindex a:0xfc4cfa00 %l 0x80088a0 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0 (LPM),1 (HPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RB_SPARE (at 0x88c)"
      tindex a:0xfc4cfa00 %l 0x80088c0 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_DVDD_RB_SPARE (at 0x88d)"
      tindex a:0xfc4cfa00 %l 0x80088d0 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_XVDD_RB_SPARE (at 0x88e)"
      tindex a:0xfc4cfa00 %l 0x80088e0 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RB_SPARE (at 0x88f)"
      tindex a:0xfc4cfa00 %l 0x80088f0 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON1_INTERFACE (at 0x890)"
      tindex a:0xfc4cfa00 %l 0x8008900 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PBS_INTERFACE (at 0x891)"
      tindex a:0xfc4cfa00 %l 0x8008910 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_FSM_CTL (at 0x894)"
      tindex a:0xfc4cfa00 %l 0x8008940 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_FSM                                  = "
    tree.end
    tree "PON_FSM_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_FSM_STATUS (at 0x895)"
      tindex a:0xfc4cfa00 %l 0x8008950 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM_STATE                                = "
    tree.end
    tree "PON_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SEC_ACCESS (at 0x8d0)"
      tindex a:0xfc4cfa00 %l 0x8008d00 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL2 (at 0x8d9)"
      tindex a:0xfc4cfa00 %l 0x8008d90 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL3 (at 0x8da)"
      tindex a:0xfc4cfa00 %l 0x8008da0 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL4 (at 0x8db)"
      tindex a:0xfc4cfa00 %l 0x8008db0 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_TEST1 (at 0x8e0)"
      tindex a:0xfc4cfa00 %l 0x8008e00 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_TEST_VAL (at 0x8e1)"
      tindex a:0xfc4cfa00 %l 0x8008e10 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST1 (at 0x8e2)"
      tindex a:0xfc4cfa00 %l 0x8008e20 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST2 (at 0x8e3)"
      tindex a:0xfc4cfa00 %l 0x8008e30 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
    tree.end
    tree "PON_TEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST3 (at 0x8e4)"
      tindex a:0xfc4cfa00 %l 0x8008e40 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST4 (at 0x8e5)"
      tindex a:0xfc4cfa00 %l 0x8008e50 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST5 (at 0x8e6)"
      tindex a:0xfc4cfa00 %l 0x8008e60 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_VMAX_SEL (at 0x8e7)"
      tindex a:0xfc4cfa00 %l 0x8008e70 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TRIM_NUM (at 0x8f0)"
      tindex a:0xfc4cfa00 %l 0x8008f00 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_TRIM (at 0x8f1)"
      tindex a:0xfc4cfa00 %l 0x8008f10 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_CNTL_2_TRIM (at 0x8f2)"
      tindex a:0xfc4cfa00 %l 0x8008f20 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_CNTL_3_TRIM (at 0x8f3)"
      tindex a:0xfc4cfa00 %l 0x8008f30 0x8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION1 (at 0x100)"
      tindex a:0xfc4cfa00 %l 0x8001000 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION2 (at 0x101)"
      tindex a:0xfc4cfa00 %l 0x8001010 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION3 (at 0x102)"
      tindex a:0xfc4cfa00 %l 0x8001020 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION4 (at 0x103)"
      tindex a:0xfc4cfa00 %l 0x8001030 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_PERPH_TYPE (at 0x104)"
      tindex a:0xfc4cfa00 %l 0x8001040 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_PERPH_SUBTYPE (at 0x105)"
      tindex a:0xfc4cfa00 %l 0x8001050 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_STATUS1 (at 0x108)"
      tindex a:0xfc4cfa00 %l 0x8001080 0x1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0, 1, 2, 3"
    tree.end
    tree "REVID_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_SEC_ACCESS (at 0x1d0)"
      tindex a:0xfc4cfa00 %l 0x8001d00 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_TEST1 (at 0x1e0)"
      tindex a:0xfc4cfa00 %l 0x8001e00 0x1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_REVISION1 (at 0x5400)"
      tindex a:0xfc4cfa00 %l 0x8054000 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_REVISION2 (at 0x5401)"
      tindex a:0xfc4cfa00 %l 0x8054010 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_REVISION3 (at 0x5402)"
      tindex a:0xfc4cfa00 %l 0x8054020 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_REVISION4 (at 0x5403)"
      tindex a:0xfc4cfa00 %l 0x8054030 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_TYPE (at 0x5404)"
      tindex a:0xfc4cfa00 %l 0x8054040 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
      tindex a:0xfc4cfa00 %l 0x8054050 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_STATUS1 (at 0x5408)"
      tindex a:0xfc4cfa00 %l 0x8054080 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK1_EDGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_EDGE_CTL1 (at 0x5443)"
      tindex a:0xfc4cfa00 %l 0x8054430 0x54430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_DRV_CTL1 (at 0x5444)"
      tindex a:0xfc4cfa00 %l 0x8054440 0x54440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_EN_CTL (at 0x5446)"
      tindex a:0xfc4cfa00 %l 0x8054460 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PD_CTL (at 0x5448)"
      tindex a:0xfc4cfa00 %l 0x8054480 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_SEC_ACCESS (at 0x54d0)"
      tindex a:0xfc4cfa00 %l 0x8054d00 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
      tindex a:0xfc4cfa00 %l 0x8054d80 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
      tindex a:0xfc4cfa00 %l 0x8054d90 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
      tindex a:0xfc4cfa00 %l 0x8054da0 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
      tindex a:0xfc4cfa00 %l 0x8054db0 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_REVISION1 (at 0x5500)"
      tindex a:0xfc4cfa00 %l 0x8055000 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_REVISION2 (at 0x5501)"
      tindex a:0xfc4cfa00 %l 0x8055010 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_REVISION3 (at 0x5502)"
      tindex a:0xfc4cfa00 %l 0x8055020 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_REVISION4 (at 0x5503)"
      tindex a:0xfc4cfa00 %l 0x8055030 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_TYPE (at 0x5504)"
      tindex a:0xfc4cfa00 %l 0x8055040 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
      tindex a:0xfc4cfa00 %l 0x8055050 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_STATUS1 (at 0x5508)"
      tindex a:0xfc4cfa00 %l 0x8055080 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK2_EDGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_EDGE_CTL1 (at 0x5543)"
      tindex a:0xfc4cfa00 %l 0x8055430 0x55430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_DRV_CTL1 (at 0x5544)"
      tindex a:0xfc4cfa00 %l 0x8055440 0x55440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_EN_CTL (at 0x5546)"
      tindex a:0xfc4cfa00 %l 0x8055460 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PD_CTL (at 0x5548)"
      tindex a:0xfc4cfa00 %l 0x8055480 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_SEC_ACCESS (at 0x55d0)"
      tindex a:0xfc4cfa00 %l 0x8055d00 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
      tindex a:0xfc4cfa00 %l 0x8055d80 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
      tindex a:0xfc4cfa00 %l 0x8055d90 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
      tindex a:0xfc4cfa00 %l 0x8055da0 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
      tindex a:0xfc4cfa00 %l 0x8055db0 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_REVISION1 (at 0x6100)"
      tindex a:0xfc4cfa00 %l 0x8061000 0x61000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_REVISION2 (at 0x6101)"
      tindex a:0xfc4cfa00 %l 0x8061010 0x61010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_TYPE (at 0x6104)"
      tindex a:0xfc4cfa00 %l 0x8061040 0x61040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
      tindex a:0xfc4cfa00 %l 0x8061050 0x61050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_STATUS1 (at 0x6108)"
      tindex a:0xfc4cfa00 %l 0x8061080 0x61080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_RT_STS (at 0x6110)"
      tindex a:0xfc4cfa00 %l 0x8061100 0x61100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
      tindex a:0xfc4cfa00 %l 0x8061110 0x61110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
      tindex a:0xfc4cfa00 %l 0x8061120 0x61120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
      tindex a:0xfc4cfa00 %l 0x8061130 0x61130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
      tindex a:0xfc4cfa00 %l 0x8061140 0x61140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_EN_SET (at 0x6115)"
      tindex a:0xfc4cfa00 %l 0x8061150 0x61150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_EN_CLR (at 0x6116)"
      tindex a:0xfc4cfa00 %l 0x8061160 0x61160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
      tindex a:0xfc4cfa00 %l 0x8061180 0x61180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
      tindex a:0xfc4cfa00 %l 0x8061190 0x61190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_MID_SEL (at 0x611a)"
      tindex a:0xfc4cfa00 %l 0x80611a0 0x611a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_PRIORITY (at 0x611b)"
      tindex a:0xfc4cfa00 %l 0x80611b0 0x611b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
      tindex a:0xfc4cfa00 %l 0x8061400 0x61400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
      tindex a:0xfc4cfa00 %l 0x8061410 0x61410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
      tindex a:0xfc4cfa00 %l 0x8061420 0x61420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
      tindex a:0xfc4cfa00 %l 0x8061430 0x61430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_EN_CTL1 (at 0x6146)"
      tindex a:0xfc4cfa00 %l 0x8061460 0x61460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_ALARM_CLR (at 0x6148)"
      tindex a:0xfc4cfa00 %l 0x8061480 0x61480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
      tindex a:0xfc4cfa00 %l 0x8061d00 0x61d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
      tindex a:0xfc4cfa00 %l 0x8061d80 0x61d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
      tindex a:0xfc4cfa00 %l 0x8061d90 0x61d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
      tindex a:0xfc4cfa00 %l 0x8061da0 0x61da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
      tindex a:0xfc4cfa00 %l 0x8061db0 0x61db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_TEST1 (at 0x61e0)"
      tindex a:0xfc4cfa00 %l 0x8061e00 0x61e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
      tindex a:0xfc4cfa00 %l 0x8061e10 0x61e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_REVISION1 (at 0x6200)"
      tindex a:0xfc4cfa00 %l 0x8062000 0x62000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_REVISION2 (at 0x6201)"
      tindex a:0xfc4cfa00 %l 0x8062010 0x62010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_TYPE (at 0x6204)"
      tindex a:0xfc4cfa00 %l 0x8062040 0x62040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
      tindex a:0xfc4cfa00 %l 0x8062050 0x62050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_STATUS1 (at 0x6208)"
      tindex a:0xfc4cfa00 %l 0x8062080 0x62080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_RT_STS (at 0x6210)"
      tindex a:0xfc4cfa00 %l 0x8062100 0x62100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
      tindex a:0xfc4cfa00 %l 0x8062110 0x62110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
      tindex a:0xfc4cfa00 %l 0x8062120 0x62120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
      tindex a:0xfc4cfa00 %l 0x8062130 0x62130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
      tindex a:0xfc4cfa00 %l 0x8062140 0x62140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_EN_SET (at 0x6215)"
      tindex a:0xfc4cfa00 %l 0x8062150 0x62150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_EN_CLR (at 0x6216)"
      tindex a:0xfc4cfa00 %l 0x8062160 0x62160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
      tindex a:0xfc4cfa00 %l 0x8062180 0x62180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
      tindex a:0xfc4cfa00 %l 0x8062190 0x62190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_MID_SEL (at 0x621a)"
      tindex a:0xfc4cfa00 %l 0x80621a0 0x621a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_PRIORITY (at 0x621b)"
      tindex a:0xfc4cfa00 %l 0x80621b0 0x621b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
      tindex a:0xfc4cfa00 %l 0x8062400 0x62400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
      tindex a:0xfc4cfa00 %l 0x8062420 0x62420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_TIMER_MODE (at 0x6245)"
      tindex a:0xfc4cfa00 %l 0x8062450 0x62450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_EN_CTL (at 0x6246)"
      tindex a:0xfc4cfa00 %l 0x8062460 0x62460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
      tindex a:0xfc4cfa00 %l 0x8062480 0x62480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
      tindex a:0xfc4cfa00 %l 0x8062490 0x62490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
      tindex a:0xfc4cfa00 %l 0x8062d00 0x62d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
      tindex a:0xfc4cfa00 %l 0x8062d80 0x62d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
      tindex a:0xfc4cfa00 %l 0x8062d90 0x62d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
      tindex a:0xfc4cfa00 %l 0x8062da0 0x62da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
      tindex a:0xfc4cfa00 %l 0x8062db0 0x62db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_TEST1 (at 0x62e0)"
      tindex a:0xfc4cfa00 %l 0x8062e00 0x62e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
      tindex a:0xfc4cfa00 %l 0x8062e10 0x62e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_WR"
  tree "RTC_WR"
    tree "RTC_WR_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_REVISION1 (at 0x6000)"
      tindex a:0xfc4cfa00 %l 0x8060000 0x60000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_WR_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_REVISION2 (at 0x6001)"
      tindex a:0xfc4cfa00 %l 0x8060010 0x60010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_WR_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_TYPE (at 0x6004)"
      tindex a:0xfc4cfa00 %l 0x8060040 0x60040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_WR_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_SUBTYPE (at 0x6005)"
      tindex a:0xfc4cfa00 %l 0x8060050 0x60050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_WR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_STATUS1 (at 0x6008)"
      tindex a:0xfc4cfa00 %l 0x8060080 0x60080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_WR_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_RT_STS (at 0x6010)"
      tindex a:0xfc4cfa00 %l 0x8060100 0x60100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_WR_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_SET_TYPE (at 0x6011)"
      tindex a:0xfc4cfa00 %l 0x8060110 0x60110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_WR_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_POLARITY_HIGH (at 0x6012)"
      tindex a:0xfc4cfa00 %l 0x8060120 0x60120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_POLARITY_LOW (at 0x6013)"
      tindex a:0xfc4cfa00 %l 0x8060130 0x60130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_LATCHED_CLR (at 0x6014)"
      tindex a:0xfc4cfa00 %l 0x8060140 0x60140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_EN_SET (at 0x6015)"
      tindex a:0xfc4cfa00 %l 0x8060150 0x60150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_WR_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_EN_CLR (at 0x6016)"
      tindex a:0xfc4cfa00 %l 0x8060160 0x60160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_LATCHED_STS (at 0x6018)"
      tindex a:0xfc4cfa00 %l 0x8060180 0x60180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_WR_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_PENDING_STS (at 0x6019)"
      tindex a:0xfc4cfa00 %l 0x8060190 0x60190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_WR_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_MID_SEL (at 0x601a)"
      tindex a:0xfc4cfa00 %l 0x80601a0 0x601a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_WR_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_PRIORITY (at 0x601b)"
      tindex a:0xfc4cfa00 %l 0x80601b0 0x601b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_WR_WDATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_WDATA0 (at 0x6040)"
      tindex a:0xfc4cfa00 %l 0x8060400 0x60400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_WR_WDATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_WDATA1 (at 0x6041)"
      tindex a:0xfc4cfa00 %l 0x8060410 0x60410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_WR_WDATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_WDATA2 (at 0x6042)"
      tindex a:0xfc4cfa00 %l 0x8060420 0x60420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_WR_WDATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_WDATA3 (at 0x6043)"
      tindex a:0xfc4cfa00 %l 0x8060430 0x60430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_WR_TIME_ADJ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_TIME_ADJ (at 0x6044)"
      tindex a:0xfc4cfa00 %l 0x8060440 0x60440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_WR_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_EN_CTL1 (at 0x6046)"
      tindex a:0xfc4cfa00 %l 0x8060460 0x60460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_WR_RDATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_RDATA0 (at 0x6048)"
      tindex a:0xfc4cfa00 %l 0x8060480 0x60480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_WR_RDATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_RDATA1 (at 0x6049)"
      tindex a:0xfc4cfa00 %l 0x8060490 0x60490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_WR_RDATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_RDATA2 (at 0x604a)"
      tindex a:0xfc4cfa00 %l 0x80604a0 0x604a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_WR_RDATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_RDATA3 (at 0x604b)"
      tindex a:0xfc4cfa00 %l 0x80604b0 0x604b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_WR_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_SEC_ACCESS (at 0x60d0)"
      tindex a:0xfc4cfa00 %l 0x8060d00 0x60d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_RESET_CTL1 (at 0x60d8)"
      tindex a:0xfc4cfa00 %l 0x8060d80 0x60d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_RESET_CTL2 (at 0x60d9)"
      tindex a:0xfc4cfa00 %l 0x8060d90 0x60d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_RESET_CTL3 (at 0x60da)"
      tindex a:0xfc4cfa00 %l 0x8060da0 0x60da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_PERPH_RESET_CTL4 (at 0x60db)"
      tindex a:0xfc4cfa00 %l 0x8060db0 0x60db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_WR_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_TEST1 (at 0x60e0)"
      tindex a:0xfc4cfa00 %l 0x8060e00 0x60e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_WR_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_INT_TEST_VAL (at 0x60e1)"
      tindex a:0xfc4cfa00 %l 0x8060e10 0x60e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_WR_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "RTC_WR_TEST1 (at 0x60e2)"
      tindex a:0xfc4cfa00 %l 0x8060e20 0x60e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION1 (at 0x11400)"
      tindex a:0xfc4cfa00 %l 0x8114000 0x114000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION2 (at 0x11401)"
      tindex a:0xfc4cfa00 %l 0x8114010 0x114010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION3 (at 0x11402)"
      tindex a:0xfc4cfa00 %l 0x8114020 0x114020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION4 (at 0x11403)"
      tindex a:0xfc4cfa00 %l 0x8114030 0x114030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_TYPE (at 0x11404)"
      tindex a:0xfc4cfa00 %l 0x8114040 0x114040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
      tindex a:0xfc4cfa00 %l 0x8114050 0x114050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STATUS (at 0x11408)"
      tindex a:0xfc4cfa00 %l 0x8114080 0x114080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_RT_STS (at 0x11410)"
      tindex a:0xfc4cfa00 %l 0x8114100 0x114100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_SET_TYPE (at 0x11411)"
      tindex a:0xfc4cfa00 %l 0x8114110 0x114110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
      tindex a:0xfc4cfa00 %l 0x8114120 0x114120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
      tindex a:0xfc4cfa00 %l 0x8114130 0x114130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
      tindex a:0xfc4cfa00 %l 0x8114140 0x114140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_EN_SET (at 0x11415)"
      tindex a:0xfc4cfa00 %l 0x8114150 0x114150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_EN_CLR (at 0x11416)"
      tindex a:0xfc4cfa00 %l 0x8114160 0x114160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
      tindex a:0xfc4cfa00 %l 0x8114180 0x114180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_PENDING_STS (at 0x11419)"
      tindex a:0xfc4cfa00 %l 0x8114190 0x114190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_MID_SEL (at 0x1141a)"
      tindex a:0xfc4cfa00 %l 0x81141a0 0x1141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_PRIORITY (at 0x1141b)"
      tindex a:0xfc4cfa00 %l 0x81141b0 0x1141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
      tindex a:0xfc4cfa00 %l 0x8114400 0x114400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
      tindex a:0xfc4cfa00 %l 0x8114410 0x114410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PFM_CTL (at 0x11444)"
      tindex a:0xfc4cfa00 %l 0x8114440 0x114440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_MODE_CTL (at 0x11445)"
      tindex a:0xfc4cfa00 %l 0x8114450 0x114450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_EN_CTL (at 0x11446)"
      tindex a:0xfc4cfa00 %l 0x8114460 0x114460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PD_CTL (at 0x11448)"
      tindex a:0xfc4cfa00 %l 0x8114480 0x114480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
      tindex a:0xfc4cfa00 %l 0x8114510 0x114510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S1_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_GM_CTL (at 0x11452)"
      tindex a:0xfc4cfa00 %l 0x8114520 0x114520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_RZ_CTL (at 0x11453)"
      tindex a:0xfc4cfa00 %l 0x8114530 0x114530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_ISNS_CTRL (at 0x11455)"
      tindex a:0xfc4cfa00 %l 0x8114550 0x114550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_SAW_CTL (at 0x11456)"
      tindex a:0xfc4cfa00 %l 0x8114560 0x114560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_DMAX_CTL (at 0x11458)"
      tindex a:0xfc4cfa00 %l 0x8114580 0x114580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
      tindex a:0xfc4cfa00 %l 0x8114590 0x114590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
      tindex a:0xfc4cfa00 %l 0x81145a0 0x1145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
      tindex a:0xfc4cfa00 %l 0x81145b0 0x1145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
      tindex a:0xfc4cfa00 %l 0x81145c0 0x1145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
      tindex a:0xfc4cfa00 %l 0x81145d0 0x1145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PS_VGA_CTL (at 0x1145e)"
      tindex a:0xfc4cfa00 %l 0x81145e0 0x1145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
      tindex a:0xfc4cfa00 %l 0x8114600 0x114600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
      tindex a:0xfc4cfa00 %l 0x8114610 0x114610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_FT_CTL (at 0x11462)"
      tindex a:0xfc4cfa00 %l 0x8114620 0x114620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S1_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_QMODE_SHADOW (at 0x11463)"
      tindex a:0xfc4cfa00 %l 0x8114630 0x114630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S1_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_UL_LL_CTRL (at 0x11468)"
      tindex a:0xfc4cfa00 %l 0x8114680 0x114680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_UL_VOLTAGE (at 0x11469)"
      tindex a:0xfc4cfa00 %l 0x8114690 0x114690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_LL_VOLTAGE (at 0x1146b)"
      tindex a:0xfc4cfa00 %l 0x81146b0 0x1146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_OCP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_OCP (at 0x1146c)"
      tindex a:0xfc4cfa00 %l 0x81146c0 0x1146c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTLR_MISC (at 0x1147a)"
      tindex a:0xfc4cfa00 %l 0x81147a0 0x1147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_SEC_ACCESS (at 0x114d0)"
      tindex a:0xfc4cfa00 %l 0x8114d00 0x114d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
      tindex a:0xfc4cfa00 %l 0x8114d80 0x114d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
      tindex a:0xfc4cfa00 %l 0x8114d90 0x114d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
      tindex a:0xfc4cfa00 %l 0x8114da0 0x114da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
      tindex a:0xfc4cfa00 %l 0x8114db0 0x114db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_TEST1 (at 0x114e0)"
      tindex a:0xfc4cfa00 %l 0x8114e00 0x114e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
      tindex a:0xfc4cfa00 %l 0x8114e10 0x114e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTLR_TEST (at 0x114e2)"
      tindex a:0xfc4cfa00 %l 0x8114e20 0x114e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_TRIM_NUM (at 0x114f0)"
      tindex a:0xfc4cfa00 %l 0x8114f00 0x114f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
      tindex a:0xfc4cfa00 %l 0x8114f10 0x114f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM2 (at 0x114f2)"
      tindex a:0xfc4cfa00 %l 0x8114f20 0x114f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM3 (at 0x114f3)"
      tindex a:0xfc4cfa00 %l 0x8114f30 0x114f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
      tindex a:0xfc4cfa00 %l 0x8114f40 0x114f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION1 (at 0x11600)"
      tindex a:0xfc4cfa00 %l 0x8116000 0x116000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION2 (at 0x11601)"
      tindex a:0xfc4cfa00 %l 0x8116010 0x116010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_TYPE (at 0x11604)"
      tindex a:0xfc4cfa00 %l 0x8116040 0x116040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
      tindex a:0xfc4cfa00 %l 0x8116050 0x116050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_ENABLE (at 0x11646)"
      tindex a:0xfc4cfa00 %l 0x8116460 0x116460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_DIV (at 0x11650)"
      tindex a:0xfc4cfa00 %l 0x8116500 0x116500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_PHASE (at 0x11651)"
      tindex a:0xfc4cfa00 %l 0x8116510 0x116510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_GANG_CTL1 (at 0x116c0)"
      tindex a:0xfc4cfa00 %l 0x8116c00 0x116c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_GANG_CTL2 (at 0x116c1)"
      tindex a:0xfc4cfa00 %l 0x8116c10 0x116c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_SEC_ACCESS (at 0x116d0)"
      tindex a:0xfc4cfa00 %l 0x8116d00 0x116d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
      tindex a:0xfc4cfa00 %l 0x8116d90 0x116d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
      tindex a:0xfc4cfa00 %l 0x8116da0 0x116da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
      tindex a:0xfc4cfa00 %l 0x8116db0 0x116db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_TEST1 (at 0x116e2)"
      tindex a:0xfc4cfa00 %l 0x8116e20 0x116e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION1 (at 0x11500)"
      tindex a:0xfc4cfa00 %l 0x8115000 0x115000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION2 (at 0x11501)"
      tindex a:0xfc4cfa00 %l 0x8115010 0x115010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION3 (at 0x11502)"
      tindex a:0xfc4cfa00 %l 0x8115020 0x115020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION4 (at 0x11503)"
      tindex a:0xfc4cfa00 %l 0x8115030 0x115030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_TYPE (at 0x11504)"
      tindex a:0xfc4cfa00 %l 0x8115040 0x115040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_SUBTYPE (at 0x11505)"
      tindex a:0xfc4cfa00 %l 0x8115050 0x115050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
      tindex a:0xfc4cfa00 %l 0x81154a0 0x1154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
      tindex a:0xfc4cfa00 %l 0x81154b0 0x1154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SOFT_START_CTL (at 0x1154c)"
      tindex a:0xfc4cfa00 %l 0x81154c0 0x1154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
      tindex a:0xfc4cfa00 %l 0x8115700 0x115700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DEAD_TIME_CTRL1 (at 0x11571)"
      tindex a:0xfc4cfa00 %l 0x8115710 0x115710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
      tindex a:0xfc4cfa00 %l 0x8115720 0x115720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_BLNK_TIME_CTL (at 0x11573)"
      tindex a:0xfc4cfa00 %l 0x8115730 0x115730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S1_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_INZERO_CTL (at 0x11574)"
      tindex a:0xfc4cfa00 %l 0x8115740 0x115740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DIG_FSM_CTL (at 0x11575)"
      tindex a:0xfc4cfa00 %l 0x8115750 0x115750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
