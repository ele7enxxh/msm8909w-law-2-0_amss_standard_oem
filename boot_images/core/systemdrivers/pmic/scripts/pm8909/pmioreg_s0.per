      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWR_STG_MISC (at 0x11579)"
      tindex a:0xfc4cfa00 %l 0x8115790 0x115790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SEC_ACCESS (at 0x115d0)"
      tindex a:0xfc4cfa00 %l 0x8115d00 0x115d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
      tindex a:0xfc4cfa00 %l 0x8115d90 0x115d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
      tindex a:0xfc4cfa00 %l 0x8115da0 0x115da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
      tindex a:0xfc4cfa00 %l 0x8115db0 0x115db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_FORCE_FET_TEST (at 0x115e3)"
      tindex a:0xfc4cfa00 %l 0x8115e30 0x115e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWR_STG_TEST (at 0x115e4)"
      tindex a:0xfc4cfa00 %l 0x8115e40 0x115e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_TRIM_NUM (at 0x115f0)"
      tindex a:0xfc4cfa00 %l 0x8115f00 0x115f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PS_TRIM1 (at 0x115f1)"
      tindex a:0xfc4cfa00 %l 0x8115f10 0x115f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PS_TRIM2 (at 0x115f2)"
      tindex a:0xfc4cfa00 %l 0x8115f20 0x115f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION1 (at 0x11700)"
      tindex a:0xfc4cfa00 %l 0x8117000 0x117000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION2 (at 0x11701)"
      tindex a:0xfc4cfa00 %l 0x8117010 0x117010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION3 (at 0x11702)"
      tindex a:0xfc4cfa00 %l 0x8117020 0x117020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION4 (at 0x11703)"
      tindex a:0xfc4cfa00 %l 0x8117030 0x117030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_TYPE (at 0x11704)"
      tindex a:0xfc4cfa00 %l 0x8117040 0x117040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
      tindex a:0xfc4cfa00 %l 0x8117050 0x117050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STATUS (at 0x11708)"
      tindex a:0xfc4cfa00 %l 0x8117080 0x117080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_RT_STS (at 0x11710)"
      tindex a:0xfc4cfa00 %l 0x8117100 0x117100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_SET_TYPE (at 0x11711)"
      tindex a:0xfc4cfa00 %l 0x8117110 0x117110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
      tindex a:0xfc4cfa00 %l 0x8117120 0x117120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
      tindex a:0xfc4cfa00 %l 0x8117130 0x117130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
      tindex a:0xfc4cfa00 %l 0x8117140 0x117140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_EN_SET (at 0x11715)"
      tindex a:0xfc4cfa00 %l 0x8117150 0x117150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_EN_CLR (at 0x11716)"
      tindex a:0xfc4cfa00 %l 0x8117160 0x117160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
      tindex a:0xfc4cfa00 %l 0x8117180 0x117180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_PENDING_STS (at 0x11719)"
      tindex a:0xfc4cfa00 %l 0x8117190 0x117190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_MID_SEL (at 0x1171a)"
      tindex a:0xfc4cfa00 %l 0x81171a0 0x1171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_PRIORITY (at 0x1171b)"
      tindex a:0xfc4cfa00 %l 0x81171b0 0x1171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
      tindex a:0xfc4cfa00 %l 0x8117400 0x117400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
      tindex a:0xfc4cfa00 %l 0x8117410 0x117410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S2_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PFM_CTL (at 0x11744)"
      tindex a:0xfc4cfa00 %l 0x8117440 0x117440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_MODE_CTL (at 0x11745)"
      tindex a:0xfc4cfa00 %l 0x8117450 0x117450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_EN_CTL (at 0x11746)"
      tindex a:0xfc4cfa00 %l 0x8117460 0x117460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PD_CTL (at 0x11748)"
      tindex a:0xfc4cfa00 %l 0x8117480 0x117480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S2_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_COMP_CAP_CTL (at 0x11751)"
      tindex a:0xfc4cfa00 %l 0x8117510 0x117510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S2_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GM_CTL (at 0x11752)"
      tindex a:0xfc4cfa00 %l 0x8117520 0x117520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S2_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_RZ_CTL (at 0x11753)"
      tindex a:0xfc4cfa00 %l 0x8117530 0x117530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S2_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_ISNS_CTRL (at 0x11755)"
      tindex a:0xfc4cfa00 %l 0x8117550 0x117550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S2_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_SAW_CTL (at 0x11756)"
      tindex a:0xfc4cfa00 %l 0x8117560 0x117560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S2_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_DMAX_CTL (at 0x11758)"
      tindex a:0xfc4cfa00 %l 0x8117580 0x117580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S2_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PULSE_SKIP_CTL (at 0x11759)"
      tindex a:0xfc4cfa00 %l 0x8117590 0x117590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S2_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PULSE_SKIP_THRES (at 0x1175a)"
      tindex a:0xfc4cfa00 %l 0x81175a0 0x1175a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S2_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_AUTO_MODE_CTL (at 0x1175b)"
      tindex a:0xfc4cfa00 %l 0x81175b0 0x1175b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S2_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INZERO_COUNT_CTL (at 0x1175c)"
      tindex a:0xfc4cfa00 %l 0x81175c0 0x1175c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S2_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PFM_COUNT_CTL (at 0x1175d)"
      tindex a:0xfc4cfa00 %l 0x81175d0 0x1175d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S2_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PS_VGA_CTL (at 0x1175e)"
      tindex a:0xfc4cfa00 %l 0x81175e0 0x1175e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S2_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STEPPER_SS_CTL (at 0x11760)"
      tindex a:0xfc4cfa00 %l 0x8117600 0x117600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STEPPER_VS_CTL (at 0x11761)"
      tindex a:0xfc4cfa00 %l 0x8117610 0x117610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_FT_CTL (at 0x11762)"
      tindex a:0xfc4cfa00 %l 0x8117620 0x117620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S2_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_QMODE_SHADOW (at 0x11763)"
      tindex a:0xfc4cfa00 %l 0x8117630 0x117630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S2_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_UL_LL_CTRL (at 0x11768)"
      tindex a:0xfc4cfa00 %l 0x8117680 0x117680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S2_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_UL_VOLTAGE (at 0x11769)"
      tindex a:0xfc4cfa00 %l 0x8117690 0x117690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S2_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_LL_VOLTAGE (at 0x1176b)"
      tindex a:0xfc4cfa00 %l 0x81176b0 0x1176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S2_CTRL_OCP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_OCP (at 0x1176c)"
      tindex a:0xfc4cfa00 %l 0x81176c0 0x1176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S2_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTLR_MISC (at 0x1177a)"
      tindex a:0xfc4cfa00 %l 0x81177a0 0x1177a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_SEC_ACCESS (at 0x117d0)"
      tindex a:0xfc4cfa00 %l 0x8117d00 0x117d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
      tindex a:0xfc4cfa00 %l 0x8117d80 0x117d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
      tindex a:0xfc4cfa00 %l 0x8117d90 0x117d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
      tindex a:0xfc4cfa00 %l 0x8117da0 0x117da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
      tindex a:0xfc4cfa00 %l 0x8117db0 0x117db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_TEST1 (at 0x117e0)"
      tindex a:0xfc4cfa00 %l 0x8117e00 0x117e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
      tindex a:0xfc4cfa00 %l 0x8117e10 0x117e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S2_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTLR_TEST (at 0x117e2)"
      tindex a:0xfc4cfa00 %l 0x8117e20 0x117e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_TRIM_NUM (at 0x117f0)"
      tindex a:0xfc4cfa00 %l 0x8117f00 0x117f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTL_TRIM1 (at 0x117f1)"
      tindex a:0xfc4cfa00 %l 0x8117f10 0x117f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S2_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTL_TRIM2 (at 0x117f2)"
      tindex a:0xfc4cfa00 %l 0x8117f20 0x117f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S2_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTL_TRIM3 (at 0x117f3)"
      tindex a:0xfc4cfa00 %l 0x8117f30 0x117f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S2_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CTL_TRIM4 (at 0x117f4)"
      tindex a:0xfc4cfa00 %l 0x8117f40 0x117f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION1 (at 0x11900)"
      tindex a:0xfc4cfa00 %l 0x8119000 0x119000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION2 (at 0x11901)"
      tindex a:0xfc4cfa00 %l 0x8119010 0x119010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_TYPE (at 0x11904)"
      tindex a:0xfc4cfa00 %l 0x8119040 0x119040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
      tindex a:0xfc4cfa00 %l 0x8119050 0x119050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_ENABLE (at 0x11946)"
      tindex a:0xfc4cfa00 %l 0x8119460 0x119460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_DIV (at 0x11950)"
      tindex a:0xfc4cfa00 %l 0x8119500 0x119500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_PHASE (at 0x11951)"
      tindex a:0xfc4cfa00 %l 0x8119510 0x119510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_GANG_CTL1 (at 0x119c0)"
      tindex a:0xfc4cfa00 %l 0x8119c00 0x119c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_GANG_CTL2 (at 0x119c1)"
      tindex a:0xfc4cfa00 %l 0x8119c10 0x119c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_SEC_ACCESS (at 0x119d0)"
      tindex a:0xfc4cfa00 %l 0x8119d00 0x119d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
      tindex a:0xfc4cfa00 %l 0x8119d90 0x119d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
      tindex a:0xfc4cfa00 %l 0x8119da0 0x119da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
      tindex a:0xfc4cfa00 %l 0x8119db0 0x119db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_TEST1 (at 0x119e2)"
      tindex a:0xfc4cfa00 %l 0x8119e20 0x119e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION1 (at 0x11800)"
      tindex a:0xfc4cfa00 %l 0x8118000 0x118000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION2 (at 0x11801)"
      tindex a:0xfc4cfa00 %l 0x8118010 0x118010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION3 (at 0x11802)"
      tindex a:0xfc4cfa00 %l 0x8118020 0x118020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION4 (at 0x11803)"
      tindex a:0xfc4cfa00 %l 0x8118030 0x118030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_TYPE (at 0x11804)"
      tindex a:0xfc4cfa00 %l 0x8118040 0x118040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_SUBTYPE (at 0x11805)"
      tindex a:0xfc4cfa00 %l 0x8118050 0x118050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PWM_CURRENT_LIM_CTL (at 0x1184a)"
      tindex a:0xfc4cfa00 %l 0x81184a0 0x1184a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S2_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PFM_CURRENT_LIM_CTL (at 0x1184b)"
      tindex a:0xfc4cfa00 %l 0x81184b0 0x1184b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S2_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_SOFT_START_CTL (at 0x1184c)"
      tindex a:0xfc4cfa00 %l 0x81184c0 0x1184c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S2_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_SWITCH_SIZE_CTL (at 0x11870)"
      tindex a:0xfc4cfa00 %l 0x8118700 0x118700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S2_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_DEAD_TIME_CTRL1 (at 0x11871)"
      tindex a:0xfc4cfa00 %l 0x8118710 0x118710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S2_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_DEAD_TIME_CTRL2 (at 0x11872)"
      tindex a:0xfc4cfa00 %l 0x8118720 0x118720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S2_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_BLNK_TIME_CTL (at 0x11873)"
      tindex a:0xfc4cfa00 %l 0x8118730 0x118730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S2_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_INZERO_CTL (at 0x11874)"
      tindex a:0xfc4cfa00 %l 0x8118740 0x118740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S2_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_DIG_FSM_CTL (at 0x11875)"
      tindex a:0xfc4cfa00 %l 0x8118750 0x118750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S2_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PWR_STG_MISC (at 0x11879)"
      tindex a:0xfc4cfa00 %l 0x8118790 0x118790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_SEC_ACCESS (at 0x118d0)"
      tindex a:0xfc4cfa00 %l 0x8118d00 0x118d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
      tindex a:0xfc4cfa00 %l 0x8118d90 0x118d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
      tindex a:0xfc4cfa00 %l 0x8118da0 0x118da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
      tindex a:0xfc4cfa00 %l 0x8118db0 0x118db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_FORCE_FET_TEST (at 0x118e3)"
      tindex a:0xfc4cfa00 %l 0x8118e30 0x118e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S2_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PWR_STG_TEST (at 0x118e4)"
      tindex a:0xfc4cfa00 %l 0x8118e40 0x118e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_TRIM_NUM (at 0x118f0)"
      tindex a:0xfc4cfa00 %l 0x8118f00 0x118f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PS_TRIM1 (at 0x118f1)"
      tindex a:0xfc4cfa00 %l 0x8118f10 0x118f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S2_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PS_TRIM2 (at 0x118f2)"
      tindex a:0xfc4cfa00 %l 0x8118f20 0x118f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION1 (at 0x11a00)"
      tindex a:0xfc4cfa00 %l 0x811a000 0x11a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION2 (at 0x11a01)"
      tindex a:0xfc4cfa00 %l 0x811a010 0x11a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION3 (at 0x11a02)"
      tindex a:0xfc4cfa00 %l 0x811a020 0x11a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION4 (at 0x11a03)"
      tindex a:0xfc4cfa00 %l 0x811a030 0x11a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_TYPE (at 0x11a04)"
      tindex a:0xfc4cfa00 %l 0x811a040 0x11a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
      tindex a:0xfc4cfa00 %l 0x811a050 0x11a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STATUS (at 0x11a08)"
      tindex a:0xfc4cfa00 %l 0x811a080 0x11a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_RT_STS (at 0x11a10)"
      tindex a:0xfc4cfa00 %l 0x811a100 0x11a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
      tindex a:0xfc4cfa00 %l 0x811a110 0x11a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
      tindex a:0xfc4cfa00 %l 0x811a120 0x11a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
      tindex a:0xfc4cfa00 %l 0x811a130 0x11a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
      tindex a:0xfc4cfa00 %l 0x811a140 0x11a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_EN_SET (at 0x11a15)"
      tindex a:0xfc4cfa00 %l 0x811a150 0x11a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_EN_CLR (at 0x11a16)"
      tindex a:0xfc4cfa00 %l 0x811a160 0x11a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
      tindex a:0xfc4cfa00 %l 0x811a180 0x11a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
      tindex a:0xfc4cfa00 %l 0x811a190 0x11a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
      tindex a:0xfc4cfa00 %l 0x811a1a0 0x11a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
      tindex a:0xfc4cfa00 %l 0x811a1b0 0x11a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
      tindex a:0xfc4cfa00 %l 0x811a400 0x11a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
      tindex a:0xfc4cfa00 %l 0x811a410 0x11a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PFM_CTL (at 0x11a44)"
      tindex a:0xfc4cfa00 %l 0x811a440 0x11a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_MODE_CTL (at 0x11a45)"
      tindex a:0xfc4cfa00 %l 0x811a450 0x11a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_EN_CTL (at 0x11a46)"
      tindex a:0xfc4cfa00 %l 0x811a460 0x11a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PD_CTL (at 0x11a48)"
      tindex a:0xfc4cfa00 %l 0x811a480 0x11a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
      tindex a:0xfc4cfa00 %l 0x811a510 0x11a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S3_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_GM_CTL (at 0x11a52)"
      tindex a:0xfc4cfa00 %l 0x811a520 0x11a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_RZ_CTL (at 0x11a53)"
      tindex a:0xfc4cfa00 %l 0x811a530 0x11a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_ISNS_CTRL (at 0x11a55)"
      tindex a:0xfc4cfa00 %l 0x811a550 0x11a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_SAW_CTL (at 0x11a56)"
      tindex a:0xfc4cfa00 %l 0x811a560 0x11a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_DMAX_CTL (at 0x11a58)"
      tindex a:0xfc4cfa00 %l 0x811a580 0x11a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
      tindex a:0xfc4cfa00 %l 0x811a590 0x11a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
      tindex a:0xfc4cfa00 %l 0x811a5a0 0x11a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
      tindex a:0xfc4cfa00 %l 0x811a5b0 0x11a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
      tindex a:0xfc4cfa00 %l 0x811a5c0 0x11a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
      tindex a:0xfc4cfa00 %l 0x811a5d0 0x11a5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PS_VGA_CTL (at 0x11a5e)"
      tindex a:0xfc4cfa00 %l 0x811a5e0 0x11a5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
      tindex a:0xfc4cfa00 %l 0x811a600 0x11a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
      tindex a:0xfc4cfa00 %l 0x811a610 0x11a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_FT_CTL (at 0x11a62)"
      tindex a:0xfc4cfa00 %l 0x811a620 0x11a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S3_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_QMODE_SHADOW (at 0x11a63)"
      tindex a:0xfc4cfa00 %l 0x811a630 0x11a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S3_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_UL_LL_CTRL (at 0x11a68)"
      tindex a:0xfc4cfa00 %l 0x811a680 0x11a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S3_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_UL_VOLTAGE (at 0x11a69)"
      tindex a:0xfc4cfa00 %l 0x811a690 0x11a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_LL_VOLTAGE (at 0x11a6b)"
      tindex a:0xfc4cfa00 %l 0x811a6b0 0x11a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_OCP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_OCP (at 0x11a6c)"
      tindex a:0xfc4cfa00 %l 0x811a6c0 0x11a6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTLR_MISC (at 0x11a7a)"
      tindex a:0xfc4cfa00 %l 0x811a7a0 0x11a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
      tindex a:0xfc4cfa00 %l 0x811ad00 0x11ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
      tindex a:0xfc4cfa00 %l 0x811ad80 0x11ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
      tindex a:0xfc4cfa00 %l 0x811ad90 0x11ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
      tindex a:0xfc4cfa00 %l 0x811ada0 0x11ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
      tindex a:0xfc4cfa00 %l 0x811adb0 0x11adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_TEST1 (at 0x11ae0)"
      tindex a:0xfc4cfa00 %l 0x811ae00 0x11ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
      tindex a:0xfc4cfa00 %l 0x811ae10 0x11ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTLR_TEST (at 0x11ae2)"
      tindex a:0xfc4cfa00 %l 0x811ae20 0x11ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_TRIM_NUM (at 0x11af0)"
      tindex a:0xfc4cfa00 %l 0x811af00 0x11af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
      tindex a:0xfc4cfa00 %l 0x811af10 0x11af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM2 (at 0x11af2)"
      tindex a:0xfc4cfa00 %l 0x811af20 0x11af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM3 (at 0x11af3)"
      tindex a:0xfc4cfa00 %l 0x811af30 0x11af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
      tindex a:0xfc4cfa00 %l 0x811af40 0x11af40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION1 (at 0x11c00)"
      tindex a:0xfc4cfa00 %l 0x811c000 0x11c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION2 (at 0x11c01)"
      tindex a:0xfc4cfa00 %l 0x811c010 0x11c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_TYPE (at 0x11c04)"
      tindex a:0xfc4cfa00 %l 0x811c040 0x11c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
      tindex a:0xfc4cfa00 %l 0x811c050 0x11c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_ENABLE (at 0x11c46)"
      tindex a:0xfc4cfa00 %l 0x811c460 0x11c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_DIV (at 0x11c50)"
      tindex a:0xfc4cfa00 %l 0x811c500 0x11c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_PHASE (at 0x11c51)"
      tindex a:0xfc4cfa00 %l 0x811c510 0x11c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
      tindex a:0xfc4cfa00 %l 0x811cc00 0x11cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
      tindex a:0xfc4cfa00 %l 0x811cc10 0x11cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
      tindex a:0xfc4cfa00 %l 0x811cd00 0x11cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
      tindex a:0xfc4cfa00 %l 0x811cd90 0x11cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
      tindex a:0xfc4cfa00 %l 0x811cda0 0x11cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
      tindex a:0xfc4cfa00 %l 0x811cdb0 0x11cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_TEST1 (at 0x11ce2)"
      tindex a:0xfc4cfa00 %l 0x811ce20 0x11ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION1 (at 0x11b00)"
      tindex a:0xfc4cfa00 %l 0x811b000 0x11b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION2 (at 0x11b01)"
      tindex a:0xfc4cfa00 %l 0x811b010 0x11b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION3 (at 0x11b02)"
      tindex a:0xfc4cfa00 %l 0x811b020 0x11b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION4 (at 0x11b03)"
      tindex a:0xfc4cfa00 %l 0x811b030 0x11b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_TYPE (at 0x11b04)"
      tindex a:0xfc4cfa00 %l 0x811b040 0x11b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
      tindex a:0xfc4cfa00 %l 0x811b050 0x11b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
      tindex a:0xfc4cfa00 %l 0x811b4a0 0x11b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
      tindex a:0xfc4cfa00 %l 0x811b4b0 0x11b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SOFT_START_CTL (at 0x11b4c)"
      tindex a:0xfc4cfa00 %l 0x811b4c0 0x11b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
      tindex a:0xfc4cfa00 %l 0x811b700 0x11b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DEAD_TIME_CTRL1 (at 0x11b71)"
      tindex a:0xfc4cfa00 %l 0x811b710 0x11b710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
      tindex a:0xfc4cfa00 %l 0x811b720 0x11b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
      tindex a:0xfc4cfa00 %l 0x811b730 0x11b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S3_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_INZERO_CTL (at 0x11b74)"
      tindex a:0xfc4cfa00 %l 0x811b740 0x11b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DIG_FSM_CTL (at 0x11b75)"
      tindex a:0xfc4cfa00 %l 0x811b750 0x11b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWR_STG_MISC (at 0x11b79)"
      tindex a:0xfc4cfa00 %l 0x811b790 0x11b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SEC_ACCESS (at 0x11bd0)"
      tindex a:0xfc4cfa00 %l 0x811bd00 0x11bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
      tindex a:0xfc4cfa00 %l 0x811bd90 0x11bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
      tindex a:0xfc4cfa00 %l 0x811bda0 0x11bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
      tindex a:0xfc4cfa00 %l 0x811bdb0 0x11bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_FORCE_FET_TEST (at 0x11be3)"
      tindex a:0xfc4cfa00 %l 0x811be30 0x11be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWR_STG_TEST (at 0x11be4)"
      tindex a:0xfc4cfa00 %l 0x811be40 0x11be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_TRIM_NUM (at 0x11bf0)"
      tindex a:0xfc4cfa00 %l 0x811bf00 0x11bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PS_TRIM1 (at 0x11bf1)"
      tindex a:0xfc4cfa00 %l 0x811bf10 0x11bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PS_TRIM2 (at 0x11bf2)"
      tindex a:0xfc4cfa00 %l 0x811bf20 0x11bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION1 (at 0x12000)"
      tindex a:0xfc4cfa00 %l 0x8120000 0x120000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION2 (at 0x12001)"
      tindex a:0xfc4cfa00 %l 0x8120010 0x120010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION3 (at 0x12002)"
      tindex a:0xfc4cfa00 %l 0x8120020 0x120020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION4 (at 0x12003)"
      tindex a:0xfc4cfa00 %l 0x8120030 0x120030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_TYPE (at 0x12004)"
      tindex a:0xfc4cfa00 %l 0x8120040 0x120040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_SUBTYPE (at 0x12005)"
      tindex a:0xfc4cfa00 %l 0x8120050 0x120050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STATUS (at 0x12008)"
      tindex a:0xfc4cfa00 %l 0x8120080 0x120080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_RT_STS (at 0x12010)"
      tindex a:0xfc4cfa00 %l 0x8120100 0x120100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_SET_TYPE (at 0x12011)"
      tindex a:0xfc4cfa00 %l 0x8120110 0x120110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_POLARITY_HIGH (at 0x12012)"
      tindex a:0xfc4cfa00 %l 0x8120120 0x120120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_POLARITY_LOW (at 0x12013)"
      tindex a:0xfc4cfa00 %l 0x8120130 0x120130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_LATCHED_CLR (at 0x12014)"
      tindex a:0xfc4cfa00 %l 0x8120140 0x120140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_EN_SET (at 0x12015)"
      tindex a:0xfc4cfa00 %l 0x8120150 0x120150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_EN_CLR (at 0x12016)"
      tindex a:0xfc4cfa00 %l 0x8120160 0x120160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_LATCHED_STS (at 0x12018)"
      tindex a:0xfc4cfa00 %l 0x8120180 0x120180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_PENDING_STS (at 0x12019)"
      tindex a:0xfc4cfa00 %l 0x8120190 0x120190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_MID_SEL (at 0x1201a)"
      tindex a:0xfc4cfa00 %l 0x81201a0 0x1201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_PRIORITY (at 0x1201b)"
      tindex a:0xfc4cfa00 %l 0x81201b0 0x1201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VOLTAGE_CTL1 (at 0x12040)"
      tindex a:0xfc4cfa00 %l 0x8120400 0x120400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VOLTAGE_CTL2 (at 0x12041)"
      tindex a:0xfc4cfa00 %l 0x8120410 0x120410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PFM_CTL (at 0x12044)"
      tindex a:0xfc4cfa00 %l 0x8120440 0x120440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_MODE_CTL (at 0x12045)"
      tindex a:0xfc4cfa00 %l 0x8120450 0x120450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_EN_CTL (at 0x12046)"
      tindex a:0xfc4cfa00 %l 0x8120460 0x120460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PD_CTL (at 0x12048)"
      tindex a:0xfc4cfa00 %l 0x8120480 0x120480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_COMP_CAP_CTL (at 0x12051)"
      tindex a:0xfc4cfa00 %l 0x8120510 0x120510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S4_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GM_CTL (at 0x12052)"
      tindex a:0xfc4cfa00 %l 0x8120520 0x120520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S4_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_RZ_CTL (at 0x12053)"
      tindex a:0xfc4cfa00 %l 0x8120530 0x120530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S4_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_ISNS_CTRL (at 0x12055)"
      tindex a:0xfc4cfa00 %l 0x8120550 0x120550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S4_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_SAW_CTL (at 0x12056)"
      tindex a:0xfc4cfa00 %l 0x8120560 0x120560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S4_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_DMAX_CTL (at 0x12058)"
      tindex a:0xfc4cfa00 %l 0x8120580 0x120580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PULSE_SKIP_CTL (at 0x12059)"
      tindex a:0xfc4cfa00 %l 0x8120590 0x120590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PULSE_SKIP_THRES (at 0x1205a)"
      tindex a:0xfc4cfa00 %l 0x81205a0 0x1205a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S4_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_AUTO_MODE_CTL (at 0x1205b)"
      tindex a:0xfc4cfa00 %l 0x81205b0 0x1205b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S4_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INZERO_COUNT_CTL (at 0x1205c)"
      tindex a:0xfc4cfa00 %l 0x81205c0 0x1205c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PFM_COUNT_CTL (at 0x1205d)"
      tindex a:0xfc4cfa00 %l 0x81205d0 0x1205d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PS_VGA_CTL (at 0x1205e)"
      tindex a:0xfc4cfa00 %l 0x81205e0 0x1205e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S4_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STEPPER_SS_CTL (at 0x12060)"
      tindex a:0xfc4cfa00 %l 0x8120600 0x120600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STEPPER_VS_CTL (at 0x12061)"
      tindex a:0xfc4cfa00 %l 0x8120610 0x120610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_FT_CTL (at 0x12062)"
      tindex a:0xfc4cfa00 %l 0x8120620 0x120620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S4_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_QMODE_SHADOW (at 0x12063)"
      tindex a:0xfc4cfa00 %l 0x8120630 0x120630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S4_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_UL_LL_CTRL (at 0x12068)"
      tindex a:0xfc4cfa00 %l 0x8120680 0x120680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S4_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_UL_VOLTAGE (at 0x12069)"
      tindex a:0xfc4cfa00 %l 0x8120690 0x120690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_LL_VOLTAGE (at 0x1206b)"
      tindex a:0xfc4cfa00 %l 0x81206b0 0x1206b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_OCP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_OCP (at 0x1206c)"
      tindex a:0xfc4cfa00 %l 0x81206c0 0x1206c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S4_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTLR_MISC (at 0x1207a)"
      tindex a:0xfc4cfa00 %l 0x81207a0 0x1207a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_SEC_ACCESS (at 0x120d0)"
      tindex a:0xfc4cfa00 %l 0x8120d00 0x120d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
      tindex a:0xfc4cfa00 %l 0x8120d80 0x120d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
      tindex a:0xfc4cfa00 %l 0x8120d90 0x120d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
      tindex a:0xfc4cfa00 %l 0x8120da0 0x120da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
      tindex a:0xfc4cfa00 %l 0x8120db0 0x120db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_TEST1 (at 0x120e0)"
      tindex a:0xfc4cfa00 %l 0x8120e00 0x120e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_TEST_VAL (at 0x120e1)"
      tindex a:0xfc4cfa00 %l 0x8120e10 0x120e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S4_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTLR_TEST (at 0x120e2)"
      tindex a:0xfc4cfa00 %l 0x8120e20 0x120e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_TRIM_NUM (at 0x120f0)"
      tindex a:0xfc4cfa00 %l 0x8120f00 0x120f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTL_TRIM1 (at 0x120f1)"
      tindex a:0xfc4cfa00 %l 0x8120f10 0x120f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S4_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTL_TRIM2 (at 0x120f2)"
      tindex a:0xfc4cfa00 %l 0x8120f20 0x120f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S4_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTL_TRIM3 (at 0x120f3)"
      tindex a:0xfc4cfa00 %l 0x8120f30 0x120f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S4_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CTL_TRIM4 (at 0x120f4)"
      tindex a:0xfc4cfa00 %l 0x8120f40 0x120f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION1 (at 0x12200)"
      tindex a:0xfc4cfa00 %l 0x8122000 0x122000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION2 (at 0x12201)"
      tindex a:0xfc4cfa00 %l 0x8122010 0x122010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_TYPE (at 0x12204)"
      tindex a:0xfc4cfa00 %l 0x8122040 0x122040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_SUBTYPE (at 0x12205)"
      tindex a:0xfc4cfa00 %l 0x8122050 0x122050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_ENABLE (at 0x12246)"
      tindex a:0xfc4cfa00 %l 0x8122460 0x122460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_DIV (at 0x12250)"
      tindex a:0xfc4cfa00 %l 0x8122500 0x122500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_PHASE (at 0x12251)"
      tindex a:0xfc4cfa00 %l 0x8122510 0x122510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_GANG_CTL1 (at 0x122c0)"
      tindex a:0xfc4cfa00 %l 0x8122c00 0x122c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_GANG_CTL2 (at 0x122c1)"
      tindex a:0xfc4cfa00 %l 0x8122c10 0x122c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_SEC_ACCESS (at 0x122d0)"
      tindex a:0xfc4cfa00 %l 0x8122d00 0x122d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
      tindex a:0xfc4cfa00 %l 0x8122d90 0x122d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
      tindex a:0xfc4cfa00 %l 0x8122da0 0x122da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
      tindex a:0xfc4cfa00 %l 0x8122db0 0x122db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_TEST1 (at 0x122e2)"
      tindex a:0xfc4cfa00 %l 0x8122e20 0x122e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION1 (at 0x12100)"
      tindex a:0xfc4cfa00 %l 0x8121000 0x121000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION2 (at 0x12101)"
      tindex a:0xfc4cfa00 %l 0x8121010 0x121010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION3 (at 0x12102)"
      tindex a:0xfc4cfa00 %l 0x8121020 0x121020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION4 (at 0x12103)"
      tindex a:0xfc4cfa00 %l 0x8121030 0x121030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_TYPE (at 0x12104)"
      tindex a:0xfc4cfa00 %l 0x8121040 0x121040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_SUBTYPE (at 0x12105)"
      tindex a:0xfc4cfa00 %l 0x8121050 0x121050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PWM_CURRENT_LIM_CTL (at 0x1214a)"
      tindex a:0xfc4cfa00 %l 0x81214a0 0x1214a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S4_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PFM_CURRENT_LIM_CTL (at 0x1214b)"
      tindex a:0xfc4cfa00 %l 0x81214b0 0x1214b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S4_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_SOFT_START_CTL (at 0x1214c)"
      tindex a:0xfc4cfa00 %l 0x81214c0 0x1214c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S4_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_SWITCH_SIZE_CTL (at 0x12170)"
      tindex a:0xfc4cfa00 %l 0x8121700 0x121700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_DEAD_TIME_CTRL1 (at 0x12171)"
      tindex a:0xfc4cfa00 %l 0x8121710 0x121710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_DEAD_TIME_CTRL2 (at 0x12172)"
      tindex a:0xfc4cfa00 %l 0x8121720 0x121720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S4_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_BLNK_TIME_CTL (at 0x12173)"
      tindex a:0xfc4cfa00 %l 0x8121730 0x121730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S4_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_INZERO_CTL (at 0x12174)"
      tindex a:0xfc4cfa00 %l 0x8121740 0x121740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S4_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_DIG_FSM_CTL (at 0x12175)"
      tindex a:0xfc4cfa00 %l 0x8121750 0x121750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S4_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PWR_STG_MISC (at 0x12179)"
      tindex a:0xfc4cfa00 %l 0x8121790 0x121790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_SEC_ACCESS (at 0x121d0)"
      tindex a:0xfc4cfa00 %l 0x8121d00 0x121d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL2 (at 0x121d9)"
      tindex a:0xfc4cfa00 %l 0x8121d90 0x121d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL3 (at 0x121da)"
      tindex a:0xfc4cfa00 %l 0x8121da0 0x121da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL4 (at 0x121db)"
      tindex a:0xfc4cfa00 %l 0x8121db0 0x121db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_FORCE_FET_TEST (at 0x121e3)"
      tindex a:0xfc4cfa00 %l 0x8121e30 0x121e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S4_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PWR_STG_TEST (at 0x121e4)"
      tindex a:0xfc4cfa00 %l 0x8121e40 0x121e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_TRIM_NUM (at 0x121f0)"
      tindex a:0xfc4cfa00 %l 0x8121f00 0x121f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PS_TRIM1 (at 0x121f1)"
      tindex a:0xfc4cfa00 %l 0x8121f10 0x121f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S4_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PS_TRIM2 (at 0x121f2)"
      tindex a:0xfc4cfa00 %l 0x8121f20 0x121f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION1 (at 0x12300)"
      tindex a:0xfc4cfa00 %l 0x8123000 0x123000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION2 (at 0x12301)"
      tindex a:0xfc4cfa00 %l 0x8123010 0x123010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION3 (at 0x12302)"
      tindex a:0xfc4cfa00 %l 0x8123020 0x123020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION4 (at 0x12303)"
      tindex a:0xfc4cfa00 %l 0x8123030 0x123030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_TYPE (at 0x12304)"
      tindex a:0xfc4cfa00 %l 0x8123040 0x123040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_SUBTYPE (at 0x12305)"
      tindex a:0xfc4cfa00 %l 0x8123050 0x123050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STATUS (at 0x12308)"
      tindex a:0xfc4cfa00 %l 0x8123080 0x123080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_RT_STS (at 0x12310)"
      tindex a:0xfc4cfa00 %l 0x8123100 0x123100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_SET_TYPE (at 0x12311)"
      tindex a:0xfc4cfa00 %l 0x8123110 0x123110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_POLARITY_HIGH (at 0x12312)"
      tindex a:0xfc4cfa00 %l 0x8123120 0x123120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_POLARITY_LOW (at 0x12313)"
      tindex a:0xfc4cfa00 %l 0x8123130 0x123130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_LATCHED_CLR (at 0x12314)"
      tindex a:0xfc4cfa00 %l 0x8123140 0x123140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_EN_SET (at 0x12315)"
      tindex a:0xfc4cfa00 %l 0x8123150 0x123150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_EN_CLR (at 0x12316)"
      tindex a:0xfc4cfa00 %l 0x8123160 0x123160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_LATCHED_STS (at 0x12318)"
      tindex a:0xfc4cfa00 %l 0x8123180 0x123180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_PENDING_STS (at 0x12319)"
      tindex a:0xfc4cfa00 %l 0x8123190 0x123190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_MID_SEL (at 0x1231a)"
      tindex a:0xfc4cfa00 %l 0x81231a0 0x1231a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_PRIORITY (at 0x1231b)"
      tindex a:0xfc4cfa00 %l 0x81231b0 0x1231b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VOLTAGE_CTL1 (at 0x12340)"
      tindex a:0xfc4cfa00 %l 0x8123400 0x123400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VOLTAGE_CTL2 (at 0x12341)"
      tindex a:0xfc4cfa00 %l 0x8123410 0x123410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PFM_CTL (at 0x12344)"
      tindex a:0xfc4cfa00 %l 0x8123440 0x123440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_MODE_CTL (at 0x12345)"
      tindex a:0xfc4cfa00 %l 0x8123450 0x123450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_EN_CTL (at 0x12346)"
      tindex a:0xfc4cfa00 %l 0x8123460 0x123460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PD_CTL (at 0x12348)"
      tindex a:0xfc4cfa00 %l 0x8123480 0x123480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S5_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_COMP_CAP_CTL (at 0x12351)"
      tindex a:0xfc4cfa00 %l 0x8123510 0x123510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S5_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GM_CTL (at 0x12352)"
      tindex a:0xfc4cfa00 %l 0x8123520 0x123520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S5_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_RZ_CTL (at 0x12353)"
      tindex a:0xfc4cfa00 %l 0x8123530 0x123530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S5_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_ISNS_CTRL (at 0x12355)"
      tindex a:0xfc4cfa00 %l 0x8123550 0x123550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S5_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_SAW_CTL (at 0x12356)"
      tindex a:0xfc4cfa00 %l 0x8123560 0x123560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S5_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_DMAX_CTL (at 0x12358)"
      tindex a:0xfc4cfa00 %l 0x8123580 0x123580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PULSE_SKIP_CTL (at 0x12359)"
      tindex a:0xfc4cfa00 %l 0x8123590 0x123590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PULSE_SKIP_THRES (at 0x1235a)"
      tindex a:0xfc4cfa00 %l 0x81235a0 0x1235a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S5_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_AUTO_MODE_CTL (at 0x1235b)"
      tindex a:0xfc4cfa00 %l 0x81235b0 0x1235b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S5_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INZERO_COUNT_CTL (at 0x1235c)"
      tindex a:0xfc4cfa00 %l 0x81235c0 0x1235c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PFM_COUNT_CTL (at 0x1235d)"
      tindex a:0xfc4cfa00 %l 0x81235d0 0x1235d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PS_VGA_CTL (at 0x1235e)"
      tindex a:0xfc4cfa00 %l 0x81235e0 0x1235e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S5_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STEPPER_SS_CTL (at 0x12360)"
      tindex a:0xfc4cfa00 %l 0x8123600 0x123600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STEPPER_VS_CTL (at 0x12361)"
      tindex a:0xfc4cfa00 %l 0x8123610 0x123610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_FT_CTL (at 0x12362)"
      tindex a:0xfc4cfa00 %l 0x8123620 0x123620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S5_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_QMODE_SHADOW (at 0x12363)"
      tindex a:0xfc4cfa00 %l 0x8123630 0x123630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S5_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_UL_LL_CTRL (at 0x12368)"
      tindex a:0xfc4cfa00 %l 0x8123680 0x123680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S5_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_UL_VOLTAGE (at 0x12369)"
      tindex a:0xfc4cfa00 %l 0x8123690 0x123690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_LL_VOLTAGE (at 0x1236b)"
      tindex a:0xfc4cfa00 %l 0x81236b0 0x1236b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_OCP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_OCP (at 0x1236c)"
      tindex a:0xfc4cfa00 %l 0x81236c0 0x1236c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S5_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTLR_MISC (at 0x1237a)"
      tindex a:0xfc4cfa00 %l 0x81237a0 0x1237a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_SEC_ACCESS (at 0x123d0)"
      tindex a:0xfc4cfa00 %l 0x8123d00 0x123d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL1 (at 0x123d8)"
      tindex a:0xfc4cfa00 %l 0x8123d80 0x123d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL2 (at 0x123d9)"
      tindex a:0xfc4cfa00 %l 0x8123d90 0x123d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL3 (at 0x123da)"
      tindex a:0xfc4cfa00 %l 0x8123da0 0x123da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL4 (at 0x123db)"
      tindex a:0xfc4cfa00 %l 0x8123db0 0x123db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_TEST1 (at 0x123e0)"
      tindex a:0xfc4cfa00 %l 0x8123e00 0x123e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_TEST_VAL (at 0x123e1)"
      tindex a:0xfc4cfa00 %l 0x8123e10 0x123e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S5_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTLR_TEST (at 0x123e2)"
      tindex a:0xfc4cfa00 %l 0x8123e20 0x123e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_TRIM_NUM (at 0x123f0)"
      tindex a:0xfc4cfa00 %l 0x8123f00 0x123f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTL_TRIM1 (at 0x123f1)"
      tindex a:0xfc4cfa00 %l 0x8123f10 0x123f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S5_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTL_TRIM2 (at 0x123f2)"
      tindex a:0xfc4cfa00 %l 0x8123f20 0x123f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S5_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTL_TRIM3 (at 0x123f3)"
      tindex a:0xfc4cfa00 %l 0x8123f30 0x123f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S5_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CTL_TRIM4 (at 0x123f4)"
      tindex a:0xfc4cfa00 %l 0x8123f40 0x123f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION1 (at 0x12500)"
      tindex a:0xfc4cfa00 %l 0x8125000 0x125000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION2 (at 0x12501)"
      tindex a:0xfc4cfa00 %l 0x8125010 0x125010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_TYPE (at 0x12504)"
      tindex a:0xfc4cfa00 %l 0x8125040 0x125040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_SUBTYPE (at 0x12505)"
      tindex a:0xfc4cfa00 %l 0x8125050 0x125050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_ENABLE (at 0x12546)"
      tindex a:0xfc4cfa00 %l 0x8125460 0x125460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_DIV (at 0x12550)"
      tindex a:0xfc4cfa00 %l 0x8125500 0x125500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_PHASE (at 0x12551)"
      tindex a:0xfc4cfa00 %l 0x8125510 0x125510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_GANG_CTL1 (at 0x125c0)"
      tindex a:0xfc4cfa00 %l 0x8125c00 0x125c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_GANG_CTL2 (at 0x125c1)"
      tindex a:0xfc4cfa00 %l 0x8125c10 0x125c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_SEC_ACCESS (at 0x125d0)"
      tindex a:0xfc4cfa00 %l 0x8125d00 0x125d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL2 (at 0x125d9)"
      tindex a:0xfc4cfa00 %l 0x8125d90 0x125d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL3 (at 0x125da)"
      tindex a:0xfc4cfa00 %l 0x8125da0 0x125da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL4 (at 0x125db)"
      tindex a:0xfc4cfa00 %l 0x8125db0 0x125db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S5_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_TEST1 (at 0x125e2)"
      tindex a:0xfc4cfa00 %l 0x8125e20 0x125e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION1 (at 0x12400)"
      tindex a:0xfc4cfa00 %l 0x8124000 0x124000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION2 (at 0x12401)"
      tindex a:0xfc4cfa00 %l 0x8124010 0x124010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION3 (at 0x12402)"
      tindex a:0xfc4cfa00 %l 0x8124020 0x124020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION4 (at 0x12403)"
      tindex a:0xfc4cfa00 %l 0x8124030 0x124030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_TYPE (at 0x12404)"
      tindex a:0xfc4cfa00 %l 0x8124040 0x124040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_SUBTYPE (at 0x12405)"
      tindex a:0xfc4cfa00 %l 0x8124050 0x124050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PWM_CURRENT_LIM_CTL (at 0x1244a)"
      tindex a:0xfc4cfa00 %l 0x81244a0 0x1244a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S5_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PFM_CURRENT_LIM_CTL (at 0x1244b)"
      tindex a:0xfc4cfa00 %l 0x81244b0 0x1244b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S5_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_SOFT_START_CTL (at 0x1244c)"
      tindex a:0xfc4cfa00 %l 0x81244c0 0x1244c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S5_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_SWITCH_SIZE_CTL (at 0x12470)"
      tindex a:0xfc4cfa00 %l 0x8124700 0x124700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_DEAD_TIME_CTRL1 (at 0x12471)"
      tindex a:0xfc4cfa00 %l 0x8124710 0x124710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_DEAD_TIME_CTRL2 (at 0x12472)"
      tindex a:0xfc4cfa00 %l 0x8124720 0x124720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S5_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_BLNK_TIME_CTL (at 0x12473)"
      tindex a:0xfc4cfa00 %l 0x8124730 0x124730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S5_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_INZERO_CTL (at 0x12474)"
      tindex a:0xfc4cfa00 %l 0x8124740 0x124740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S5_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_DIG_FSM_CTL (at 0x12475)"
      tindex a:0xfc4cfa00 %l 0x8124750 0x124750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S5_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PWR_STG_MISC (at 0x12479)"
      tindex a:0xfc4cfa00 %l 0x8124790 0x124790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_SEC_ACCESS (at 0x124d0)"
      tindex a:0xfc4cfa00 %l 0x8124d00 0x124d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL2 (at 0x124d9)"
      tindex a:0xfc4cfa00 %l 0x8124d90 0x124d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL3 (at 0x124da)"
      tindex a:0xfc4cfa00 %l 0x8124da0 0x124da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL4 (at 0x124db)"
      tindex a:0xfc4cfa00 %l 0x8124db0 0x124db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S5_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_FORCE_FET_TEST (at 0x124e3)"
      tindex a:0xfc4cfa00 %l 0x8124e30 0x124e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S5_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PWR_STG_TEST (at 0x124e4)"
      tindex a:0xfc4cfa00 %l 0x8124e40 0x124e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_TRIM_NUM (at 0x124f0)"
      tindex a:0xfc4cfa00 %l 0x8124f00 0x124f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PS_TRIM1 (at 0x124f1)"
      tindex a:0xfc4cfa00 %l 0x8124f10 0x124f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S5_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PS_TRIM2 (at 0x124f2)"
      tindex a:0xfc4cfa00 %l 0x8124f20 0x124f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_REVISION1 (at 0x5a00)"
      tindex a:0xfc4cfa00 %l 0x805a000 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_REVISION2 (at 0x5a01)"
      tindex a:0xfc4cfa00 %l 0x805a010 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
      tindex a:0xfc4cfa00 %l 0x805a040 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
      tindex a:0xfc4cfa00 %l 0x805a050 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_STATUS1 (at 0x5a08)"
      tindex a:0xfc4cfa00 %l 0x805a080 0x5a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_OK                               = " "0 (SLP_CLK_BUFFER_OFF),1 (SLP_CLK_BUFFER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (XO_32K),1 (EXT_32K),2 (CALRC),3 (LFRC),4 (RC19M_DIV),5 (XO19M_DIV),6 (RESERVED),7 (reserved)"
    tree.end
    tree "SLEEP_CLK1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_RT_STS (at 0x5a10)"
      tindex a:0xfc4cfa00 %l 0x805a100 0x5a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_RT_STS                    = " "0 (XO32K_NOT_HALT),1 (XO32K_HALT)"
    tree.end
    tree "SLEEP_CLK1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_SET_TYPE (at 0x5a11)"
      tindex a:0xfc4cfa00 %l 0x805a110 0x5a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_POLARITY_HIGH (at 0x5a12)"
      tindex a:0xfc4cfa00 %l 0x805a120 0x5a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_POLARITY_LOW (at 0x5a13)"
      tindex a:0xfc4cfa00 %l 0x805a130 0x5a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_LATCHED_CLR (at 0x5a14)"
      tindex a:0xfc4cfa00 %l 0x805a140 0x5a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_EN_SET (at 0x5a15)"
      tindex a:0xfc4cfa00 %l 0x805a150 0x5a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_EN_CLR (at 0x5a16)"
      tindex a:0xfc4cfa00 %l 0x805a160 0x5a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_LATCHED_STS (at 0x5a18)"
      tindex a:0xfc4cfa00 %l 0x805a180 0x5a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "SLEEP_CLK1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_PENDING_STS (at 0x5a19)"
      tindex a:0xfc4cfa00 %l 0x805a190 0x5a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "SLEEP_CLK1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_MID_SEL (at 0x5a1a)"
      tindex a:0xfc4cfa00 %l 0x805a1a0 0x5a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SLEEP_CLK1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_PRIORITY (at 0x5a1b)"
      tindex a:0xfc4cfa00 %l 0x805a1b0 0x5a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
      tindex a:0xfc4cfa00 %l 0x805a440 0x5a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_HALT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_HALT_CTL (at 0x5a45)"
      tindex a:0xfc4cfa00 %l 0x805a450 0x5a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_HALT_EN                            = " "0 (XO32K_HALT_DISABLED),1 (XO32K_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO32K_OSC_HALT                     = " "0 (XO32K_HALT_NOT_FORCED),1 (XO32K_HALT_FORCED)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_EN_CTL (at 0x5a46)"
      tindex a:0xfc4cfa00 %l 0x805a460 0x5a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_PAD_EN                           = " "0 (SLP_CLK_BUF_DISABLED),1 (SLP_CLK_BUF_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_SMPL_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_SMPL_CTL1 (at 0x5a48)"
      tindex a:0xfc4cfa00 %l 0x805a480 0x5a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SMPL_DELAY                               = " "0 (HALF_SEC),1 (ONE_SEC),2 (ONEANDHALF_SEC),3 (TWO_SEC)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
      tindex a:0xfc4cfa00 %l 0x805a490 0x5a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_EN                                 = " "0 (XO32K_DISABLED),1 (XO32K_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_OSC_SEL2I                          = " "0 (NORMAL_CURRENT),1 (MORE_CURRENT)"
    tree.end
    tree "SLEEP_CLK1_LFRC_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_LFRC_CTL (at 0x5a57)"
      tindex a:0xfc4cfa00 %l 0x805a570 0x5a570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLKS_XVDD_BLEED                          = " "0 (NA_0),1 (NA_200),2 (reserved),3 (NA_600),4 (reserved),5 (reserved),6 (reserved),7 (NA_1600)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
      tindex a:0xfc4cfa00 %l 0x805a580 0x5a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
      tindex a:0xfc4cfa00 %l 0x805a590 0x5a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
      tindex a:0xfc4cfa00 %l 0x805a5a0 0x5a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
      tindex a:0xfc4cfa00 %l 0x805a5b0 0x5a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
      tindex a:0xfc4cfa00 %l 0x805a5c0 0x5a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
      tindex a:0xfc4cfa00 %l 0x805ad00 0x5ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
      tindex a:0xfc4cfa00 %l 0x805ad80 0x5ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
      tindex a:0xfc4cfa00 %l 0x805ad90 0x5ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
      tindex a:0xfc4cfa00 %l 0x805ada0 0x5ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
      tindex a:0xfc4cfa00 %l 0x805adb0 0x5adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
      tindex a:0xfc4cfa00 %l 0x805adc0 0x5adc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
      tindex a:0xfc4cfa00 %l 0x805add0 0x5add0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_TEST1 (at 0x5ae0)"
      tindex a:0xfc4cfa00 %l 0x805ae00 0x5ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "SLEEP_CLK1_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_INT_TEST_VAL (at 0x5ae1)"
      tindex a:0xfc4cfa00 %l 0x805ae10 0x5ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TEST_VAL                  = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SLEEP_CLK1_TEST1 (at 0x5ae2)"
      tindex a:0xfc4cfa00 %l 0x805ae20 0x5ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMPL_TRIGGER_SEL                         = " "0 (HIZ),1 (CONNECT_TO_DTEST)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CXVDD_ATEST_EN                           = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION1 (at 0x600)"
      tindex a:0xfc4cfa00 %l 0x8006000 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION2 (at 0x601)"
      tindex a:0xfc4cfa00 %l 0x8006010 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION3 (at 0x602)"
      tindex a:0xfc4cfa00 %l 0x8006020 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION4 (at 0x603)"
      tindex a:0xfc4cfa00 %l 0x8006030 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_TYPE (at 0x604)"
      tindex a:0xfc4cfa00 %l 0x8006040 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_SUBTYPE (at 0x605)"
      tindex a:0xfc4cfa00 %l 0x8006050 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_SYNDROME (at 0x608)"
      tindex a:0xfc4cfa00 %l 0x8006080 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_DATA (at 0x60b)"
      tindex a:0xfc4cfa00 %l 0x80060b0 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_ADDR_LO (at 0x60c)"
      tindex a:0xfc4cfa00 %l 0x80060c0 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_ADDR_MD (at 0x60d)"
      tindex a:0xfc4cfa00 %l 0x80060d0 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_ADDR_HI (at 0x60e)"
      tindex a:0xfc4cfa00 %l 0x80060e0 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_RT_STS (at 0x610)"
      tindex a:0xfc4cfa00 %l 0x8006100 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_SET_TYPE (at 0x611)"
      tindex a:0xfc4cfa00 %l 0x8006110 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_POLARITY_HIGH (at 0x612)"
      tindex a:0xfc4cfa00 %l 0x8006120 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_POLARITY_LOW (at 0x613)"
      tindex a:0xfc4cfa00 %l 0x8006130 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_LATCHED_CLR (at 0x614)"
      tindex a:0xfc4cfa00 %l 0x8006140 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_EN_SET (at 0x615)"
      tindex a:0xfc4cfa00 %l 0x8006150 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_EN_CLR (at 0x616)"
      tindex a:0xfc4cfa00 %l 0x8006160 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_LATCHED_STS (at 0x618)"
      tindex a:0xfc4cfa00 %l 0x8006180 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_PENDING_STS (at 0x619)"
      tindex a:0xfc4cfa00 %l 0x8006190 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_MID_SEL (at 0x61a)"
      tindex a:0xfc4cfa00 %l 0x80061a0 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_PRIORITY (at 0x61b)"
      tindex a:0xfc4cfa00 %l 0x80061b0 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_SPMI_BUF_CFG (at 0x640)"
      tindex a:0xfc4cfa00 %l 0x8006400 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_SEC_ACCESS (at 0x6d0)"
      tindex a:0xfc4cfa00 %l 0x8006d00 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
      tindex a:0xfc4cfa00 %l 0x8006d90 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
      tindex a:0xfc4cfa00 %l 0x8006da0 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
      tindex a:0xfc4cfa00 %l 0x8006db0 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_TEST1 (at 0x6e0)"
      tindex a:0xfc4cfa00 %l 0x8006e00 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_TEST_VAL (at 0x6e1)"
      tindex a:0xfc4cfa00 %l 0x8006e10 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_TEST1 (at 0x6e2)"
      tindex a:0xfc4cfa00 %l 0x8006e20 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
      tindex a:0xfc4cfa00 %l 0x8206430 0x206430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
      tindex a:0xfc4cfa00 %l 0x8206440 0x206440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
      tindex a:0xfc4cfa00 %l 0x8206450 0x206450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
      tindex a:0xfc4cfa00 %l 0x8206460 0x206460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
      tindex a:0xfc4cfa00 %l 0x8206470 0x206470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION1 (at 0x2400)"
      tindex a:0xfc4cfa00 %l 0x8024000 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION2 (at 0x2401)"
      tindex a:0xfc4cfa00 %l 0x8024010 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION3 (at 0x2402)"
      tindex a:0xfc4cfa00 %l 0x8024020 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION4 (at 0x2403)"
      tindex a:0xfc4cfa00 %l 0x8024030 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
      tindex a:0xfc4cfa00 %l 0x8024040 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
      tindex a:0xfc4cfa00 %l 0x8024050 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_STATUS1 (at 0x2408)"
      tindex a:0xfc4cfa00 %l 0x8024080 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_RT_STS (at 0x2410)"
      tindex a:0xfc4cfa00 %l 0x8024100 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
      tindex a:0xfc4cfa00 %l 0x8024110 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
      tindex a:0xfc4cfa00 %l 0x8024120 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
      tindex a:0xfc4cfa00 %l 0x8024130 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
      tindex a:0xfc4cfa00 %l 0x8024140 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_EN_SET (at 0x2415)"
      tindex a:0xfc4cfa00 %l 0x8024150 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
      tindex a:0xfc4cfa00 %l 0x8024160 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
      tindex a:0xfc4cfa00 %l 0x8024180 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
      tindex a:0xfc4cfa00 %l 0x8024190 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
      tindex a:0xfc4cfa00 %l 0x80241a0 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
      tindex a:0xfc4cfa00 %l 0x80241b0 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
      tindex a:0xfc4cfa00 %l 0x8024400 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
      tindex a:0xfc4cfa00 %l 0x8024420 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_EN_CTL1 (at 0x2446)"
      tindex a:0xfc4cfa00 %l 0x8024460 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
      tindex a:0xfc4cfa00 %l 0x8024d00 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
      tindex a:0xfc4cfa00 %l 0x8024d80 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
      tindex a:0xfc4cfa00 %l 0x8024d90 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
      tindex a:0xfc4cfa00 %l 0x8024da0 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
      tindex a:0xfc4cfa00 %l 0x8024db0 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
      tindex a:0xfc4cfa00 %l 0x8024e00 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
      tindex a:0xfc4cfa00 %l 0x8024e10 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TEST1 (at 0x24e2)"
      tindex a:0xfc4cfa00 %l 0x8024e20 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TEST2 (at 0x24e3)"
      tindex a:0xfc4cfa00 %l 0x8024e30 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
      tindex a:0xfc4cfa00 %l 0x8024f00 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
      tindex a:0xfc4cfa00 %l 0x8024f10 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION1 (at 0xfe00)"
      tindex a:0xfc4cfa00 %l 0x80fe000 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION2 (at 0xfe01)"
      tindex a:0xfc4cfa00 %l 0x80fe010 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION3 (at 0xfe02)"
      tindex a:0xfc4cfa00 %l 0x80fe020 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION4 (at 0xfe03)"
      tindex a:0xfc4cfa00 %l 0x80fe030 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_TYPE (at 0xfe04)"
      tindex a:0xfc4cfa00 %l 0x80fe040 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_SUBTYPE (at 0xfe05)"
      tindex a:0xfc4cfa00 %l 0x80fe050 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
      tindex a:0xfc4cfa00 %l 0x80fe080 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_PROG_STATUS (at 0xfe09)"
      tindex a:0xfc4cfa00 %l 0x80fe090 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
      tindex a:0xfc4cfa00 %l 0x80fe0a0 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
      tindex a:0xfc4cfa00 %l 0x80fe0b0 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_SEC_ACCESS (at 0xfed0)"
      tindex a:0xfc4cfa00 %l 0x80fed00 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
      tindex a:0xfc4cfa00 %l 0x80fed90 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
      tindex a:0xfc4cfa00 %l 0x80feda0 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
      tindex a:0xfc4cfa00 %l 0x80fedb0 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
      tindex a:0xfc4cfa00 %l 0x80fee00 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
      tindex a:0xfc4cfa00 %l 0x80fee10 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
      tindex a:0xfc4cfa00 %l 0x80fee20 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
      tindex a:0xfc4cfa00 %l 0x80fee30 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
      tindex a:0xfc4cfa00 %l 0x80fee40 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TEST1 (at 0xfee5)"
      tindex a:0xfc4cfa00 %l 0x80fee50 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
      tindex a:0xfc4cfa00 %l 0x80fee60 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "VADC1_USR"
  tree "VADC1_USR"
    tree "VADC1_USR_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_REVISION1 (at 0x3100)"
      tindex a:0xfc4cfa00 %l 0x8031000 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_REVISION2 (at 0x3101)"
      tindex a:0xfc4cfa00 %l 0x8031010 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_USR_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_REVISION3 (at 0x3102)"
      tindex a:0xfc4cfa00 %l 0x8031020 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_REVISION4 (at 0x3103)"
      tindex a:0xfc4cfa00 %l 0x8031030 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_USR_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_TYPE (at 0x3104)"
      tindex a:0xfc4cfa00 %l 0x8031040 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_USR_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_SUBTYPE (at 0x3105)"
      tindex a:0xfc4cfa00 %l 0x8031050 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_USR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_STATUS1 (at 0x3108)"
      tindex a:0xfc4cfa00 %l 0x8031080 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_USR_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_STATUS2 (at 0x3109)"
      tindex a:0xfc4cfa00 %l 0x8031090 0x31090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_RT_STS (at 0x3110)"
      tindex a:0xfc4cfa00 %l 0x8031100 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_SET_TYPE (at 0x3111)"
      tindex a:0xfc4cfa00 %l 0x8031110 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_POLARITY_HIGH (at 0x3112)"
      tindex a:0xfc4cfa00 %l 0x8031120 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_POLARITY_LOW (at 0x3113)"
      tindex a:0xfc4cfa00 %l 0x8031130 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_LATCHED_CLR (at 0x3114)"
      tindex a:0xfc4cfa00 %l 0x8031140 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_USR_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_EN_SET (at 0x3115)"
      tindex a:0xfc4cfa00 %l 0x8031150 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_EN_CLR (at 0x3116)"
      tindex a:0xfc4cfa00 %l 0x8031160 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_LATCHED_STS (at 0x3118)"
      tindex a:0xfc4cfa00 %l 0x8031180 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_USR_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_PENDING_STS (at 0x3119)"
      tindex a:0xfc4cfa00 %l 0x8031190 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_USR_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_MID_SEL (at 0x311a)"
      tindex a:0xfc4cfa00 %l 0x80311a0 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_USR_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_PRIORITY (at 0x311b)"
      tindex a:0xfc4cfa00 %l 0x80311b0 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_USR_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MODE_CTL (at 0x3140)"
      tindex a:0xfc4cfa00 %l 0x8031400 0x31400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_USR_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_EN_CTL1 (at 0x3146)"
      tindex a:0xfc4cfa00 %l 0x8031460 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_USR_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_ADC_CH_SEL_CTL (at 0x3148)"
      tindex a:0xfc4cfa00 %l 0x8031480 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_USR_ADC_DIG_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_ADC_DIG_PARAM (at 0x3150)"
      tindex a:0xfc4cfa00 %l 0x8031500 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_USR_HW_SETTLE_DELAY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_HW_SETTLE_DELAY (at 0x3151)"
      tindex a:0xfc4cfa00 %l 0x8031510 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_USR_CONV_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_CONV_REQ (at 0x3152)"
      tindex a:0xfc4cfa00 %l 0x8031520 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_USR_CONV_SEQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_CONV_SEQ_CTL (at 0x3154)"
      tindex a:0xfc4cfa00 %l 0x8031540 0x31540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_USR_CONV_SEQ_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
      tindex a:0xfc4cfa00 %l 0x8031550 0x31550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MEAS_INTERVAL_CTL (at 0x3157)"
      tindex a:0xfc4cfa00 %l 0x8031570 0x31570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_OP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
      tindex a:0xfc4cfa00 %l 0x8031590 0x31590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_USR_FAST_AVG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_FAST_AVG_CTL (at 0x315a)"
      tindex a:0xfc4cfa00 %l 0x80315a0 0x315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_USR_FAST_AVG_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_FAST_AVG_EN (at 0x315b)"
      tindex a:0xfc4cfa00 %l 0x80315b0 0x315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_USR_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_LOW_THR0 (at 0x315c)"
      tindex a:0xfc4cfa00 %l 0x80315c0 0x315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_USR_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_LOW_THR1 (at 0x315d)"
      tindex a:0xfc4cfa00 %l 0x80315d0 0x315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_HIGH_THR0 (at 0x315e)"
      tindex a:0xfc4cfa00 %l 0x80315e0 0x315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_HIGH_THR1 (at 0x315f)"
      tindex a:0xfc4cfa00 %l 0x80315f0 0x315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_USR_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_DATA0 (at 0x3160)"
      tindex a:0xfc4cfa00 %l 0x8031600 0x31600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_USR_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_DATA1 (at 0x3161)"
      tindex a:0xfc4cfa00 %l 0x8031610 0x31610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MIN_LOW_THR0 (at 0x3162)"
      tindex a:0xfc4cfa00 %l 0x8031620 0x31620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MIN_LOW_THR1 (at 0x3163)"
      tindex a:0xfc4cfa00 %l 0x8031630 0x31630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC1_USR_MIN_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MIN_DATA0 (at 0x3166)"
      tindex a:0xfc4cfa00 %l 0x8031660 0x31660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC1_USR_MIN_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_MIN_DATA1 (at 0x3167)"
      tindex a:0xfc4cfa00 %l 0x8031670 0x31670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC1_USR_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_SEC_ACCESS (at 0x31d0)"
      tindex a:0xfc4cfa00 %l 0x8031d00 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
      tindex a:0xfc4cfa00 %l 0x8031d80 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
      tindex a:0xfc4cfa00 %l 0x8031d90 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_RESET_CTL3 (at 0x31da)"
      tindex a:0xfc4cfa00 %l 0x8031da0 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_PERPH_RESET_CTL4 (at 0x31db)"
      tindex a:0xfc4cfa00 %l 0x8031db0 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_TEST1 (at 0x31e0)"
      tindex a:0xfc4cfa00 %l 0x8031e00 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_INT_TEST_VAL (at 0x31e1)"
      tindex a:0xfc4cfa00 %l 0x8031e10 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_USR_TEST1_ADC_ANA_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
      tindex a:0xfc4cfa00 %l 0x8031e20 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_USR_TEST2_ADC_DIG_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
      tindex a:0xfc4cfa00 %l 0x8031e30 0x31e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_USR_TEST3_ADC_RSV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST3_ADC_RSV (at 0x31e4)"
      tindex a:0xfc4cfa00 %l 0x8031e40 0x31e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_USR_TEST4_ADC_ATEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST4_ADC_ATEST (at 0x31e5)"
      tindex a:0xfc4cfa00 %l 0x8031e50 0x31e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_USR_TEST5_AMUX_ATEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST5_AMUX_ATEST (at 0x31e6)"
      tindex a:0xfc4cfa00 %l 0x8031e60 0x31e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_USR_TEST6_DTEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TEST6_DTEST (at 0x31e7)"
      tindex a:0xfc4cfa00 %l 0x8031e70 0x31e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_USR_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM_NUM (at 0x31f0)"
      tindex a:0xfc4cfa00 %l 0x8031f00 0x31f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_USR_TRIM1_ADC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM1_ADC (at 0x31f1)"
      tindex a:0xfc4cfa00 %l 0x8031f10 0x31f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_USR_TRIM1_AMUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM1_AMUX (at 0x31f2)"
      tindex a:0xfc4cfa00 %l 0x8031f20 0x31f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM2_AMUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM2_AMUX (at 0x31f3)"
      tindex a:0xfc4cfa00 %l 0x8031f30 0x31f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM4_AMUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM4_AMUX (at 0x31f4)"
      tindex a:0xfc4cfa00 %l 0x8031f40 0x31f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_USR_TRIM5_AMUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC1_USR_TRIM5_AMUX (at 0x31f5)"
      tindex a:0xfc4cfa00 %l 0x8031f50 0x31f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "VADC2_BTM"
  tree "VADC2_BTM"
    tree "VADC2_BTM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_REVISION1 (at 0x3400)"
      tindex a:0xfc4cfa00 %l 0x8034000 0x34000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_REVISION2 (at 0x3401)"
      tindex a:0xfc4cfa00 %l 0x8034010 0x34010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_REVISION3 (at 0x3402)"
      tindex a:0xfc4cfa00 %l 0x8034020 0x34020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_REVISION4 (at 0x3403)"
      tindex a:0xfc4cfa00 %l 0x8034030 0x34030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_TYPE (at 0x3404)"
      tindex a:0xfc4cfa00 %l 0x8034040 0x34040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC2_BTM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_SUBTYPE (at 0x3405)"
      tindex a:0xfc4cfa00 %l 0x8034050 0x34050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC2_BTM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_STATUS1 (at 0x3408)"
      tindex a:0xfc4cfa00 %l 0x8034080 0x34080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC2_BTM_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_STATUS2 (at 0x3409)"
      tindex a:0xfc4cfa00 %l 0x8034090 0x34090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_STATUS_LOW (at 0x340a)"
      tindex a:0xfc4cfa00 %l 0x80340a0 0x340a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW                                   = " "0 (M7_LOW_FALSE),1 (M7_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW                                   = " "0 (M6_LOW_FALSE),1 (M6_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW                                   = " "0 (M5_LOW_FALSE),1 (M5_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW                                   = " "0 (M4_LOW_FALSE),1 (M4_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW                                   = " "0 (M3_LOW_FALSE),1 (M3_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW                                   = " "0 (M2_LOW_FALSE),1 (M2_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW                                   = " "0 (M1_LOW_FALSE),1 (M1_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW                                   = " "0 (M0_LOW_FALSE),1 (M0_LOW_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_STATUS_HIGH (at 0x340b)"
      tindex a:0xfc4cfa00 %l 0x80340b0 0x340b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH                                  = " "0 (M7_HIGH_FALSE),1 (M7_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH                                  = " "0 (M6_HIGH_FALSE),1 (M6_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH                                  = " "0 (M5_HIGH_FALSE),1 (M5_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH                                  = " "0 (M4_HIGH_FALSE),1 (M4_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH                                  = " "0 (M3_HIGH_FALSE),1 (M3_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH                                  = " "0 (M2_HIGH_FALSE),1 (M2_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH                                  = " "0 (M1_HIGH_FALSE),1 (M1_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH                                  = " "0 (M0_HIGH_FALSE),1 (M0_HIGH_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_RT_STS (at 0x3410)"
      tindex a:0xfc4cfa00 %l 0x8034100 0x34100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC2_BTM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_SET_TYPE (at 0x3411)"
      tindex a:0xfc4cfa00 %l 0x8034110 0x34110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_POLARITY_HIGH (at 0x3412)"
      tindex a:0xfc4cfa00 %l 0x8034120 0x34120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_POLARITY_LOW (at 0x3413)"
      tindex a:0xfc4cfa00 %l 0x8034130 0x34130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_LATCHED_CLR (at 0x3414)"
      tindex a:0xfc4cfa00 %l 0x8034140 0x34140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC2_BTM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_EN_SET (at 0x3415)"
      tindex a:0xfc4cfa00 %l 0x8034150 0x34150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_EN_CLR (at 0x3416)"
      tindex a:0xfc4cfa00 %l 0x8034160 0x34160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_LATCHED_STS (at 0x3418)"
      tindex a:0xfc4cfa00 %l 0x8034180 0x34180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_PENDING_STS (at 0x3419)"
      tindex a:0xfc4cfa00 %l 0x8034190 0x34190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_MID_SEL (at 0x341a)"
      tindex a:0xfc4cfa00 %l 0x80341a0 0x341a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC2_BTM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_PRIORITY (at 0x341b)"
      tindex a:0xfc4cfa00 %l 0x80341b0 0x341b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC2_BTM_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_MODE_CTL (at 0x3440)"
      tindex a:0xfc4cfa00 %l 0x8034400 0x34400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC2_BTM_MULTI_MEAS_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_MULTI_MEAS_EN (at 0x3441)"
      tindex a:0xfc4cfa00 %l 0x8034410 0x34410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_MEAS_EN                               = " "0 (M7_MEAS_DISABLE),1 (M7_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_MEAS_EN                               = " "0 (M6_MEAS_DISABLE),1 (M6_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_MEAS_EN                               = " "0 (M5_MEAS_DISABLE),1 (M5_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_MEAS_EN                               = " "0 (M4_MEAS_DISABLE),1 (M4_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_MEAS_EN                               = " "0 (M3_MEAS_DISABLE),1 (M3_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_MEAS_EN                               = " "0 (M2_MEAS_DISABLE),1 (M2_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_MEAS_EN                               = " "0 (M1_MEAS_DISABLE),1 (M1_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_MEAS_EN                               = " "0 (M0_MEAS_DISABLE),1 (M0_MEAS_ENABLE)"
    tree.end
    tree "VADC2_BTM_LOW_THR_INT_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_LOW_THR_INT_EN (at 0x3442)"
      tindex a:0xfc4cfa00 %l 0x8034420 0x34420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW_THR_INT_EN                        = " "0 (M7_LOW_THR_INT_DISABLED),1 (M7_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW_THR_INT_EN                        = " "0 (M6_LOW_THR_INT_DISABLED),1 (M6_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW_THR_INT_EN                        = " "0 (M5_LOW_THR_INT_DISABLED),1 (M5_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW_THR_INT_EN                        = " "0 (M4_LOW_THR_INT_DISABLED),1 (M4_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW_THR_INT_EN                        = " "0 (M3_LOW_THR_INT_DISABLED),1 (M3_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW_THR_INT_EN                        = " "0 (M2_LOW_THR_INT_DISABLED),1 (M2_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW_THR_INT_EN                        = " "0 (M1_LOW_THR_INT_DISABLED),1 (M1_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW_THR_INT_EN                        = " "0 (M0_LOW_THR_INT_DISABLED),1 (M0_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_HIGH_THR_INT_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_HIGH_THR_INT_EN (at 0x3443)"
      tindex a:0xfc4cfa00 %l 0x8034430 0x34430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH_THR_INT_EN                       = " "0 (M7_HIGH_THR_INT_DISABLED),1 (M7_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH_THR_INT_EN                       = " "0 (M6_HIGH_THR_INT_DISABLED),1 (M6_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH_THR_INT_EN                       = " "0 (M5_HIGH_THR_INT_DISABLED),1 (M5_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH_THR_INT_EN                       = " "0 (M4_HIGH_THR_INT_DISABLED),1 (M4_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH_THR_INT_EN                       = " "0 (M3_HIGH_THR_INT_DISABLED),1 (M3_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH_THR_INT_EN                       = " "0 (M2_HIGH_THR_INT_DISABLED),1 (M2_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH_THR_INT_EN                       = " "0 (M1_HIGH_THR_INT_DISABLED),1 (M1_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH_THR_INT_EN                       = " "0 (M0_HIGH_THR_INT_DISABLED),1 (M0_HIGH_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_EN_CTL1 (at 0x3446)"
      tindex a:0xfc4cfa00 %l 0x8034460 0x34460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_ADC_CH_SEL_CTL (at 0x3448)"
      tindex a:0xfc4cfa00 %l 0x8034480 0x34480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_ADC_DIG_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_ADC_DIG_PARAM (at 0x3450)"
      tindex a:0xfc4cfa00 %l 0x8034500 0x34500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC2_BTM_HW_SETTLE_DELAY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_HW_SETTLE_DELAY (at 0x3451)"
      tindex a:0xfc4cfa00 %l 0x8034510 0x34510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC2_BTM_CONV_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_CONV_REQ (at 0x3452)"
      tindex a:0xfc4cfa00 %l 0x8034520 0x34520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC2_BTM_CONV_SEQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_CONV_SEQ_CTL (at 0x3454)"
      tindex a:0xfc4cfa00 %l 0x8034540 0x34540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC2_BTM_CONV_SEQ_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_CONV_SEQ_TRIG_CTL (at 0x3455)"
      tindex a:0xfc4cfa00 %l 0x8034550 0x34550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_MEAS_INTERVAL_CTL (at 0x3457)"
      tindex a:0xfc4cfa00 %l 0x8034570 0x34570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME1                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_MEAS_INTERVAL_CTL2 (at 0x3458)"
      tindex a:0xfc4cfa00 %l 0x8034580 0x34580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MEAS_INTERVAL_TIME2                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME3                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_OP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_MEAS_INTERVAL_OP_CTL (at 0x3459)"
      tindex a:0xfc4cfa00 %l 0x8034590 0x34590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M0_MEAS_INTERVAL_TIME                    = " "0 (M0_USING_TIMER1),1 (M0_USING_TIMER2),2 (M0_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_FAST_AVG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_FAST_AVG_CTL (at 0x345a)"
      tindex a:0xfc4cfa00 %l 0x80345a0 0x345a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC2_BTM_FAST_AVG_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_FAST_AVG_EN (at 0x345b)"
      tindex a:0xfc4cfa00 %l 0x80345b0 0x345b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_LOW_THR0 (at 0x345c)"
      tindex a:0xfc4cfa00 %l 0x80345c0 0x345c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M0_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_LOW_THR1 (at 0x345d)"
      tindex a:0xfc4cfa00 %l 0x80345d0 0x345d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_HIGH_THR0 (at 0x345e)"
      tindex a:0xfc4cfa00 %l 0x80345e0 0x345e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_HIGH_THR1 (at 0x345f)"
      tindex a:0xfc4cfa00 %l 0x80345f0 0x345f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M0_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_DATA0 (at 0x3460)"
      tindex a:0xfc4cfa00 %l 0x8034600 0x34600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M0_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M0_DATA1 (at 0x3461)"
      tindex a:0xfc4cfa00 %l 0x8034610 0x34610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M1_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_ADC_CH_SEL_CTL (at 0x3468)"
      tindex a:0xfc4cfa00 %l 0x8034680 0x34680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_LOW_THR0 (at 0x3469)"
      tindex a:0xfc4cfa00 %l 0x8034690 0x34690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_LOW_THR1 (at 0x346a)"
      tindex a:0xfc4cfa00 %l 0x80346a0 0x346a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_HIGH_THR0 (at 0x346b)"
      tindex a:0xfc4cfa00 %l 0x80346b0 0x346b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_HIGH_THR1 (at 0x346c)"
      tindex a:0xfc4cfa00 %l 0x80346c0 0x346c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M1_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_MEAS_INTERVAL_CTL (at 0x346d)"
      tindex a:0xfc4cfa00 %l 0x80346d0 0x346d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M1_MEAS_INTERVAL_TIME                    = " "0 (M1_USING_TIMER1),1 (M1_USING_TIMER2),2 (M1_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M2_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_ADC_CH_SEL_CTL (at 0x3470)"
      tindex a:0xfc4cfa00 %l 0x8034700 0x34700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_LOW_THR0 (at 0x3471)"
      tindex a:0xfc4cfa00 %l 0x8034710 0x34710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_LOW_THR1 (at 0x3472)"
      tindex a:0xfc4cfa00 %l 0x8034720 0x34720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_HIGH_THR0 (at 0x3473)"
      tindex a:0xfc4cfa00 %l 0x8034730 0x34730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_HIGH_THR1 (at 0x3474)"
      tindex a:0xfc4cfa00 %l 0x8034740 0x34740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M2_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_MEAS_INTERVAL_CTL (at 0x3475)"
      tindex a:0xfc4cfa00 %l 0x8034750 0x34750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M2_MEAS_INTERVAL_TIME                    = " "0 (M2_USING_TIMER1),1 (M2_USING_TIMER2),2 (M2_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M3_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_ADC_CH_SEL_CTL (at 0x3478)"
      tindex a:0xfc4cfa00 %l 0x8034780 0x34780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_LOW_THR0 (at 0x3479)"
      tindex a:0xfc4cfa00 %l 0x8034790 0x34790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_LOW_THR1 (at 0x347a)"
      tindex a:0xfc4cfa00 %l 0x80347a0 0x347a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_HIGH_THR0 (at 0x347b)"
      tindex a:0xfc4cfa00 %l 0x80347b0 0x347b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_HIGH_THR1 (at 0x347c)"
      tindex a:0xfc4cfa00 %l 0x80347c0 0x347c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M3_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_MEAS_INTERVAL_CTL (at 0x347d)"
      tindex a:0xfc4cfa00 %l 0x80347d0 0x347d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M3_MEAS_INTERVAL_TIME                    = " "0 (M3_USING_TIMER1),1 (M3_USING_TIMER2),2 (M3_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M4_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_ADC_CH_SEL_CTL (at 0x3480)"
      tindex a:0xfc4cfa00 %l 0x8034800 0x34800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_LOW_THR0 (at 0x3481)"
      tindex a:0xfc4cfa00 %l 0x8034810 0x34810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_LOW_THR1 (at 0x3482)"
      tindex a:0xfc4cfa00 %l 0x8034820 0x34820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_HIGH_THR0 (at 0x3483)"
      tindex a:0xfc4cfa00 %l 0x8034830 0x34830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_HIGH_THR1 (at 0x3484)"
      tindex a:0xfc4cfa00 %l 0x8034840 0x34840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M4_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_MEAS_INTERVAL_CTL (at 0x3485)"
      tindex a:0xfc4cfa00 %l 0x8034850 0x34850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M4_MEAS_INTERVAL_TIME                    = " "0 (M4_USING_TIMER1),1 (M4_USING_TIMER2),2 (M4_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M5_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_ADC_CH_SEL_CTL (at 0x3488)"
      tindex a:0xfc4cfa00 %l 0x8034880 0x34880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_LOW_THR0 (at 0x3489)"
      tindex a:0xfc4cfa00 %l 0x8034890 0x34890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_LOW_THR1 (at 0x348a)"
      tindex a:0xfc4cfa00 %l 0x80348a0 0x348a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_HIGH_THR0 (at 0x348b)"
      tindex a:0xfc4cfa00 %l 0x80348b0 0x348b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_HIGH_THR1 (at 0x348c)"
      tindex a:0xfc4cfa00 %l 0x80348c0 0x348c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M5_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_MEAS_INTERVAL_CTL (at 0x348d)"
      tindex a:0xfc4cfa00 %l 0x80348d0 0x348d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M5_MEAS_INTERVAL_TIME                    = " "0 (M5_USING_TIMER1),1 (M5_USING_TIMER2),2 (M5_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M6_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_ADC_CH_SEL_CTL (at 0x3490)"
      tindex a:0xfc4cfa00 %l 0x8034900 0x34900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_LOW_THR0 (at 0x3491)"
      tindex a:0xfc4cfa00 %l 0x8034910 0x34910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_LOW_THR1 (at 0x3492)"
      tindex a:0xfc4cfa00 %l 0x8034920 0x34920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_HIGH_THR0 (at 0x3493)"
      tindex a:0xfc4cfa00 %l 0x8034930 0x34930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_HIGH_THR1 (at 0x3494)"
      tindex a:0xfc4cfa00 %l 0x8034940 0x34940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M6_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_MEAS_INTERVAL_CTL (at 0x3495)"
      tindex a:0xfc4cfa00 %l 0x8034950 0x34950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M6_MEAS_INTERVAL_TIME                    = " "0 (M6_USING_TIMER1),1 (M6_USING_TIMER2),2 (M6_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M7_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_ADC_CH_SEL_CTL (at 0x3498)"
      tindex a:0xfc4cfa00 %l 0x8034980 0x34980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_LOW_THR0 (at 0x3499)"
      tindex a:0xfc4cfa00 %l 0x8034990 0x34990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_LOW_THR1 (at 0x349a)"
      tindex a:0xfc4cfa00 %l 0x80349a0 0x349a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_HIGH_THR0 (at 0x349b)"
      tindex a:0xfc4cfa00 %l 0x80349b0 0x349b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_HIGH_THR1 (at 0x349c)"
      tindex a:0xfc4cfa00 %l 0x80349c0 0x349c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M7_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_MEAS_INTERVAL_CTL (at 0x349d)"
      tindex a:0xfc4cfa00 %l 0x80349d0 0x349d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M7_MEAS_INTERVAL_TIME                    = " "0 (M7_USING_TIMER1),1 (M7_USING_TIMER2),2 (M7_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M1_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_DATA0 (at 0x34a0)"
      tindex a:0xfc4cfa00 %l 0x8034a00 0x34a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M1_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M1_DATA1 (at 0x34a1)"
      tindex a:0xfc4cfa00 %l 0x8034a10 0x34a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M2_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_DATA0 (at 0x34a2)"
      tindex a:0xfc4cfa00 %l 0x8034a20 0x34a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M2_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M2_DATA1 (at 0x34a3)"
      tindex a:0xfc4cfa00 %l 0x8034a30 0x34a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M3_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_DATA0 (at 0x34a4)"
      tindex a:0xfc4cfa00 %l 0x8034a40 0x34a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M3_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M3_DATA1 (at 0x34a5)"
      tindex a:0xfc4cfa00 %l 0x8034a50 0x34a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M4_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_DATA0 (at 0x34a6)"
      tindex a:0xfc4cfa00 %l 0x8034a60 0x34a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M4_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M4_DATA1 (at 0x34a7)"
      tindex a:0xfc4cfa00 %l 0x8034a70 0x34a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M5_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_DATA0 (at 0x34a8)"
      tindex a:0xfc4cfa00 %l 0x8034a80 0x34a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M5_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M5_DATA1 (at 0x34a9)"
      tindex a:0xfc4cfa00 %l 0x8034a90 0x34a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M6_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_DATA0 (at 0x34aa)"
      tindex a:0xfc4cfa00 %l 0x8034aa0 0x34aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M6_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M6_DATA1 (at 0x34ab)"
      tindex a:0xfc4cfa00 %l 0x8034ab0 0x34ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M7_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_DATA0 (at 0x34ac)"
      tindex a:0xfc4cfa00 %l 0x8034ac0 0x34ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M7_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_M7_DATA1 (at 0x34ad)"
      tindex a:0xfc4cfa00 %l 0x8034ad0 0x34ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_SEC_ACCESS (at 0x34d0)"
      tindex a:0xfc4cfa00 %l 0x8034d00 0x34d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_RESET_CTL1 (at 0x34d8)"
      tindex a:0xfc4cfa00 %l 0x8034d80 0x34d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_RESET_CTL2 (at 0x34d9)"
      tindex a:0xfc4cfa00 %l 0x8034d90 0x34d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_RESET_CTL3 (at 0x34da)"
      tindex a:0xfc4cfa00 %l 0x8034da0 0x34da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_PERPH_RESET_CTL4 (at 0x34db)"
      tindex a:0xfc4cfa00 %l 0x8034db0 0x34db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_TEST1 (at 0x34e0)"
      tindex a:0xfc4cfa00 %l 0x8034e00 0x34e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_INT_TEST_VAL (at 0x34e1)"
      tindex a:0xfc4cfa00 %l 0x8034e10 0x34e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC2_BTM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC2_BTM_TEST1 (at 0x34e2)"
      tindex a:0xfc4cfa00 %l 0x8034e20 0x34e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "VADC3_MDM"
  tree "VADC3_MDM"
    tree "VADC3_MDM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_REVISION1 (at 0x3200)"
      tindex a:0xfc4cfa00 %l 0x8032000 0x32000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_REVISION2 (at 0x3201)"
      tindex a:0xfc4cfa00 %l 0x8032010 0x32010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_REVISION3 (at 0x3202)"
      tindex a:0xfc4cfa00 %l 0x8032020 0x32020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_REVISION4 (at 0x3203)"
      tindex a:0xfc4cfa00 %l 0x8032030 0x32030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_TYPE (at 0x3204)"
      tindex a:0xfc4cfa00 %l 0x8032040 0x32040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_MDM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_SUBTYPE (at 0x3205)"
      tindex a:0xfc4cfa00 %l 0x8032050 0x32050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_MDM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_STATUS1 (at 0x3208)"
      tindex a:0xfc4cfa00 %l 0x8032080 0x32080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_MDM_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_STATUS2 (at 0x3209)"
      tindex a:0xfc4cfa00 %l 0x8032090 0x32090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_RT_STS (at 0x3210)"
      tindex a:0xfc4cfa00 %l 0x8032100 0x32100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_SET_TYPE (at 0x3211)"
      tindex a:0xfc4cfa00 %l 0x8032110 0x32110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_POLARITY_HIGH (at 0x3212)"
      tindex a:0xfc4cfa00 %l 0x8032120 0x32120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_POLARITY_LOW (at 0x3213)"
      tindex a:0xfc4cfa00 %l 0x8032130 0x32130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_LATCHED_CLR (at 0x3214)"
      tindex a:0xfc4cfa00 %l 0x8032140 0x32140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_MDM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_EN_SET (at 0x3215)"
      tindex a:0xfc4cfa00 %l 0x8032150 0x32150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_EN_CLR (at 0x3216)"
      tindex a:0xfc4cfa00 %l 0x8032160 0x32160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_LATCHED_STS (at 0x3218)"
      tindex a:0xfc4cfa00 %l 0x8032180 0x32180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_PENDING_STS (at 0x3219)"
      tindex a:0xfc4cfa00 %l 0x8032190 0x32190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_MID_SEL (at 0x321a)"
      tindex a:0xfc4cfa00 %l 0x80321a0 0x321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_MDM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_PRIORITY (at 0x321b)"
      tindex a:0xfc4cfa00 %l 0x80321b0 0x321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_MDM_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MODE_CTL (at 0x3240)"
      tindex a:0xfc4cfa00 %l 0x8032400 0x32400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_MDM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_EN_CTL1 (at 0x3246)"
      tindex a:0xfc4cfa00 %l 0x8032460 0x32460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_MDM_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_ADC_CH_SEL_CTL (at 0x3248)"
      tindex a:0xfc4cfa00 %l 0x8032480 0x32480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_MDM_ADC_DIG_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_ADC_DIG_PARAM (at 0x3250)"
      tindex a:0xfc4cfa00 %l 0x8032500 0x32500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_MDM_HW_SETTLE_DELAY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_HW_SETTLE_DELAY (at 0x3251)"
      tindex a:0xfc4cfa00 %l 0x8032510 0x32510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_MDM_CONV_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_CONV_REQ (at 0x3252)"
      tindex a:0xfc4cfa00 %l 0x8032520 0x32520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_MDM_CONV_SEQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_CONV_SEQ_CTL (at 0x3254)"
      tindex a:0xfc4cfa00 %l 0x8032540 0x32540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_MDM_CONV_SEQ_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_CONV_SEQ_TRIG_CTL (at 0x3255)"
      tindex a:0xfc4cfa00 %l 0x8032550 0x32550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MEAS_INTERVAL_CTL (at 0x3257)"
      tindex a:0xfc4cfa00 %l 0x8032570 0x32570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_OP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MEAS_INTERVAL_OP_CTL (at 0x3259)"
      tindex a:0xfc4cfa00 %l 0x8032590 0x32590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_MDM_FAST_AVG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_FAST_AVG_CTL (at 0x325a)"
      tindex a:0xfc4cfa00 %l 0x80325a0 0x325a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_MDM_FAST_AVG_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_FAST_AVG_EN (at 0x325b)"
      tindex a:0xfc4cfa00 %l 0x80325b0 0x325b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_MDM_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_LOW_THR0 (at 0x325c)"
      tindex a:0xfc4cfa00 %l 0x80325c0 0x325c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_MDM_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_LOW_THR1 (at 0x325d)"
      tindex a:0xfc4cfa00 %l 0x80325d0 0x325d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_HIGH_THR0 (at 0x325e)"
      tindex a:0xfc4cfa00 %l 0x80325e0 0x325e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_HIGH_THR1 (at 0x325f)"
      tindex a:0xfc4cfa00 %l 0x80325f0 0x325f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_MDM_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_DATA0 (at 0x3260)"
      tindex a:0xfc4cfa00 %l 0x8032600 0x32600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_MDM_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_DATA1 (at 0x3261)"
      tindex a:0xfc4cfa00 %l 0x8032610 0x32610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MIN_LOW_THR0 (at 0x3262)"
      tindex a:0xfc4cfa00 %l 0x8032620 0x32620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MIN_LOW_THR1 (at 0x3263)"
      tindex a:0xfc4cfa00 %l 0x8032630 0x32630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_MDM_MIN_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MIN_DATA0 (at 0x3266)"
      tindex a:0xfc4cfa00 %l 0x8032660 0x32660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_MDM_MIN_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_MIN_DATA1 (at 0x3267)"
      tindex a:0xfc4cfa00 %l 0x8032670 0x32670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_MDM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_SEC_ACCESS (at 0x32d0)"
      tindex a:0xfc4cfa00 %l 0x8032d00 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
      tindex a:0xfc4cfa00 %l 0x8032d80 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
      tindex a:0xfc4cfa00 %l 0x8032d90 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_RESET_CTL3 (at 0x32da)"
      tindex a:0xfc4cfa00 %l 0x8032da0 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_PERPH_RESET_CTL4 (at 0x32db)"
      tindex a:0xfc4cfa00 %l 0x8032db0 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_TEST1 (at 0x32e0)"
      tindex a:0xfc4cfa00 %l 0x8032e00 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_INT_TEST_VAL (at 0x32e1)"
      tindex a:0xfc4cfa00 %l 0x8032e10 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_MDM_TEST6_DTEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_MDM_TEST6_DTEST (at 0x32e7)"
      tindex a:0xfc4cfa00 %l 0x8032e70 0x32e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VADC3_VBAT"
  tree "VADC3_VBAT"
    tree "VADC3_VBAT_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_REVISION1 (at 0x3500)"
      tindex a:0xfc4cfa00 %l 0x8035000 0x35000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_REVISION2 (at 0x3501)"
      tindex a:0xfc4cfa00 %l 0x8035010 0x35010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_REVISION3 (at 0x3502)"
      tindex a:0xfc4cfa00 %l 0x8035020 0x35020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_REVISION4 (at 0x3503)"
      tindex a:0xfc4cfa00 %l 0x8035030 0x35030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_VBAT_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_TYPE (at 0x3504)"
      tindex a:0xfc4cfa00 %l 0x8035040 0x35040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_VBAT_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_SUBTYPE (at 0x3505)"
      tindex a:0xfc4cfa00 %l 0x8035050 0x35050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_VBAT_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_STATUS1 (at 0x3508)"
      tindex a:0xfc4cfa00 %l 0x8035080 0x35080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_VBAT_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_STATUS2 (at 0x3509)"
      tindex a:0xfc4cfa00 %l 0x8035090 0x35090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_RT_STS (at 0x3510)"
      tindex a:0xfc4cfa00 %l 0x8035100 0x35100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_SET_TYPE (at 0x3511)"
      tindex a:0xfc4cfa00 %l 0x8035110 0x35110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_VBAT_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_POLARITY_HIGH (at 0x3512)"
      tindex a:0xfc4cfa00 %l 0x8035120 0x35120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_VBAT_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_POLARITY_LOW (at 0x3513)"
      tindex a:0xfc4cfa00 %l 0x8035130 0x35130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_VBAT_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_LATCHED_CLR (at 0x3514)"
      tindex a:0xfc4cfa00 %l 0x8035140 0x35140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_VBAT_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_EN_SET (at 0x3515)"
      tindex a:0xfc4cfa00 %l 0x8035150 0x35150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_VBAT_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_EN_CLR (at 0x3516)"
      tindex a:0xfc4cfa00 %l 0x8035160 0x35160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_VBAT_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_LATCHED_STS (at 0x3518)"
      tindex a:0xfc4cfa00 %l 0x8035180 0x35180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_PENDING_STS (at 0x3519)"
      tindex a:0xfc4cfa00 %l 0x8035190 0x35190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_MID_SEL (at 0x351a)"
      tindex a:0xfc4cfa00 %l 0x80351a0 0x351a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_VBAT_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_PRIORITY (at 0x351b)"
      tindex a:0xfc4cfa00 %l 0x80351b0 0x351b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_VBAT_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MODE_CTL (at 0x3540)"
      tindex a:0xfc4cfa00 %l 0x8035400 0x35400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_VBAT_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_EN_CTL1 (at 0x3546)"
      tindex a:0xfc4cfa00 %l 0x8035460 0x35460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_VBAT_ADC_CH_SEL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_ADC_CH_SEL_CTL (at 0x3548)"
      tindex a:0xfc4cfa00 %l 0x8035480 0x35480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_VBAT_ADC_DIG_PARAM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_ADC_DIG_PARAM (at 0x3550)"
      tindex a:0xfc4cfa00 %l 0x8035500 0x35500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_VBAT_HW_SETTLE_DELAY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_HW_SETTLE_DELAY (at 0x3551)"
      tindex a:0xfc4cfa00 %l 0x8035510 0x35510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_VBAT_CONV_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_CONV_REQ (at 0x3552)"
      tindex a:0xfc4cfa00 %l 0x8035520 0x35520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_VBAT_CONV_SEQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_CONV_SEQ_CTL (at 0x3554)"
      tindex a:0xfc4cfa00 %l 0x8035540 0x35540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_VBAT_CONV_SEQ_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_CONV_SEQ_TRIG_CTL (at 0x3555)"
      tindex a:0xfc4cfa00 %l 0x8035550 0x35550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_VBAT_MEAS_INTERVAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MEAS_INTERVAL_CTL (at 0x3557)"
      tindex a:0xfc4cfa00 %l 0x8035570 0x35570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_VBAT_MEAS_INTERVAL_OP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MEAS_INTERVAL_OP_CTL (at 0x3559)"
      tindex a:0xfc4cfa00 %l 0x8035590 0x35590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_VBAT_FAST_AVG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_FAST_AVG_CTL (at 0x355a)"
      tindex a:0xfc4cfa00 %l 0x80355a0 0x355a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_VBAT_FAST_AVG_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_FAST_AVG_EN (at 0x355b)"
      tindex a:0xfc4cfa00 %l 0x80355b0 0x355b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_VBAT_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_LOW_THR0 (at 0x355c)"
      tindex a:0xfc4cfa00 %l 0x80355c0 0x355c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_VBAT_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_LOW_THR1 (at 0x355d)"
      tindex a:0xfc4cfa00 %l 0x80355d0 0x355d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_VBAT_HIGH_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_HIGH_THR0 (at 0x355e)"
      tindex a:0xfc4cfa00 %l 0x80355e0 0x355e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_VBAT_HIGH_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_HIGH_THR1 (at 0x355f)"
      tindex a:0xfc4cfa00 %l 0x80355f0 0x355f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_VBAT_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_DATA0 (at 0x3560)"
      tindex a:0xfc4cfa00 %l 0x8035600 0x35600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_VBAT_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_DATA1 (at 0x3561)"
      tindex a:0xfc4cfa00 %l 0x8035610 0x35610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_VBAT_MIN_LOW_THR0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MIN_LOW_THR0 (at 0x3562)"
      tindex a:0xfc4cfa00 %l 0x8035620 0x35620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_VBAT_MIN_LOW_THR1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MIN_LOW_THR1 (at 0x3563)"
      tindex a:0xfc4cfa00 %l 0x8035630 0x35630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_VBAT_MIN_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MIN_DATA0 (at 0x3566)"
      tindex a:0xfc4cfa00 %l 0x8035660 0x35660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_VBAT_MIN_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_MIN_DATA1 (at 0x3567)"
      tindex a:0xfc4cfa00 %l 0x8035670 0x35670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_VBAT_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_SEC_ACCESS (at 0x35d0)"
      tindex a:0xfc4cfa00 %l 0x8035d00 0x35d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_RESET_CTL1 (at 0x35d8)"
      tindex a:0xfc4cfa00 %l 0x8035d80 0x35d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_RESET_CTL2 (at 0x35d9)"
      tindex a:0xfc4cfa00 %l 0x8035d90 0x35d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_RESET_CTL3 (at 0x35da)"
      tindex a:0xfc4cfa00 %l 0x8035da0 0x35da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_PERPH_RESET_CTL4 (at 0x35db)"
      tindex a:0xfc4cfa00 %l 0x8035db0 0x35db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_TEST1 (at 0x35e0)"
      tindex a:0xfc4cfa00 %l 0x8035e00 0x35e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_INT_TEST_VAL (at 0x35e1)"
      tindex a:0xfc4cfa00 %l 0x8035e10 0x35e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_VBAT_TEST6_DTEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VADC3_VBAT_TEST6_DTEST (at 0x35e7)"
      tindex a:0xfc4cfa00 %l 0x8035e70 0x35e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_REVISION1 (at 0xa00)"
      tindex a:0xfc4cfa00 %l 0x800a000 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_REVISION2 (at 0xa01)"
      tindex a:0xfc4cfa00 %l 0x800a010 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_REVISION3 (at 0xa02)"
      tindex a:0xfc4cfa00 %l 0x800a020 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_REVISION4 (at 0xa03)"
      tindex a:0xfc4cfa00 %l 0x800a030 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_TYPE (at 0xa04)"
      tindex a:0xfc4cfa00 %l 0x800a040 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
      tindex a:0xfc4cfa00 %l 0x800a050 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_STATUS1 (at 0xa08)"
      tindex a:0xfc4cfa00 %l 0x800a080 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR_OK                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_VREF_LPDDR2_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_VREF_LPDDR2_EN (at 0xa44)"
      tindex a:0xfc4cfa00 %l 0x800a440 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_EN_CTL1 (at 0xa46)"
      tindex a:0xfc4cfa00 %l 0x800a460 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_SEC_ACCESS (at 0xad0)"
      tindex a:0xfc4cfa00 %l 0x800ad00 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
      tindex a:0xfc4cfa00 %l 0x800ad80 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
      tindex a:0xfc4cfa00 %l 0x800ad90 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
      tindex a:0xfc4cfa00 %l 0x800ada0 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
      tindex a:0xfc4cfa00 %l 0x800adb0 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_TRIM_NUM (at 0xaf0)"
      tindex a:0xfc4cfa00 %l 0x800af00 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "VREFLPDDR_TRIM_VAL (at 0xaf1)"
      tindex a:0xfc4cfa00 %l 0x800af10 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_REVISION1 (at 0x5000)"
      tindex a:0xfc4cfa00 %l 0x8050000 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_REVISION2 (at 0x5001)"
      tindex a:0xfc4cfa00 %l 0x8050010 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_REVISION3 (at 0x5002)"
      tindex a:0xfc4cfa00 %l 0x8050020 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_REVISION4 (at 0x5003)"
      tindex a:0xfc4cfa00 %l 0x8050030 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_PERPH_TYPE (at 0x5004)"
      tindex a:0xfc4cfa00 %l 0x8050040 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_PERPH_SUBTYPE (at 0x5005)"
      tindex a:0xfc4cfa00 %l 0x8050050 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_STATUS1 (at 0x5008)"
      tindex a:0xfc4cfa00 %l 0x8050080 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0 (XO19M_OFF),1 (XO19M_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_VOLTAGE_CTL1 (at 0x5040)"
      tindex a:0xfc4cfa00 %l 0x8050400 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_MODE_CTL1 (at 0x5044)"
      tindex a:0xfc4cfa00 %l 0x8050440 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUFF_CORNER                        = " "0 (LOW_CORNER),1 (HIGH_CORNER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_EN_CTL (at 0x5046)"
      tindex a:0xfc4cfa00 %l 0x8050460 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO19M_NOT_FORCED),1 (XO19M_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_TIMER1 (at 0x504c)"
      tindex a:0xfc4cfa00 %l 0x80504c0 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XO_TIMER_LSB                             = "
    tree.end
    tree "XO_XO_TIMER2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_TIMER2 (at 0x504d)"
      tindex a:0xfc4cfa00 %l 0x80504d0 0x504d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XO_TIMER_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "XO_XO_STEPPER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_STEPPER (at 0x505a)"
      tindex a:0xfc4cfa00 %l 0x80505a0 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_ADJ_FINE (at 0x505c)"
      tindex a:0xfc4cfa00 %l 0x80505c0 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_XO_ADJ_COARSE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_ADJ_COARSE (at 0x505b)"
      tindex a:0xfc4cfa00 %l 0x80505b0 0x505b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FIXED_CAP_EN1                         = " "0 (FIX_CAP1_DIS),1 (FIX_CAP1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XO_FIXED_CAP_EN2                         = " "0 (FIX_CAP2_DIS),1 (FIX_CAP2_EN)"
    tree.end
    tree "XO_XO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_XO_CTL (at 0x505e)"
      tindex a:0xfc4cfa00 %l 0x80505e0 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICTL_MIS4                                = " "0 (XO_BIAS3_DIS),1 (XO_BIAS3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICTL_MIS3                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ICTL_MIS2                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICTL_MIS1                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ICTL_SLP                                 = " "0 (XO_BIAS1_DIS),1 (XO_BIAS1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
    tree.end
    tree "XO_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_SEC_ACCESS (at 0x50d0)"
      tindex a:0xfc4cfa00 %l 0x8050d00 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_PERPH_RESET_CTL2 (at 0x50d9)"
      tindex a:0xfc4cfa00 %l 0x8050d90 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_PERPH_RESET_CTL3 (at 0x50da)"
      tindex a:0xfc4cfa00 %l 0x8050da0 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_PERPH_RESET_CTL4 (at 0x50db)"
      tindex a:0xfc4cfa00 %l 0x8050db0 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "XO_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_TEST1 (at 0x50e2)"
      tindex a:0xfc4cfa00 %l 0x8050e20 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (XO19M),2 (OUTBUG_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "XO_TEST2 (at 0x50e4)"
      tindex a:0xfc4cfa00 %l 0x8050e40 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_DIV2_EN                               = " "0 (RF_DIV2_DIS),1 (RF_DIV2_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (DRIVE_RF_NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   XO_38P4_MODE_EN                          = " "0 (XO_19P2_MODE),1 (XO_38P4_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (DRIVE_BB_NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
    tree.end
  tree.end
tree.end
