entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CALRC2"
  tree "CALRC2"
    tree "CALRC2_REVISION1"
      sgroup "CALRC2_REVISION1 (at 0x5e00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CALRC2_REVISION2"
      sgroup "CALRC2_REVISION2 (at 0x5e01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CALRC2_PERPH_TYPE"
      sgroup "CALRC2_PERPH_TYPE (at 0x5e04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CALRC2_PERPH_SUBTYPE"
      sgroup "CALRC2_PERPH_SUBTYPE (at 0x5e05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CALRC2_STATUS1"
      sgroup "CALRC2_STATUS1 (at 0x5e08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CALRC_XODIV                              = " "0 (CALRC_RUN),1 (XODIV_RUN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LFRC_DRIFT                               = " "0 (NO_LFRC_DRIFT),1 (LFRC_DRIFT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SLOPE_DRIFT                              = " "0 (NO_SLOPE_DRIFT),1 (SLOPE_DRIFT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_DRIFT                                 = " "0 (NO_XO_DRIFT),1 (XO_DRIFT)"
    tree.end
    tree "CALRC2_CALRC_CFG"
      sgroup "CALRC2_CALRC_CFG (at 0x5e50)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "CALRC2_RC_CNT_PSLP"
      sgroup "CALRC2_RC_CNT_PSLP (at 0x5e51)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RC_CNT_PSLP                              = "
    tree.end
    tree "CALRC2_RC_CNT_PRTC"
      sgroup "CALRC2_RC_CNT_PRTC (at 0x5e52)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RC_CNT_PRTC                              = "
    tree.end
    tree "CALRC2_EST_UPD_PSLP"
      sgroup "CALRC2_EST_UPD_PSLP (at 0x5e53)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   EST_UPD_PSLP                             = " "0 (EST_UPD_MAX1),1 (EST_UPD_MAX2),2 (EST_UPD_MAX4),3 (EST_UPD_MAX8),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "CALRC2_EST_UPD_PRTC"
      sgroup "CALRC2_EST_UPD_PRTC (at 0x5e54)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   EST_UPD_PRTC                             = " "0 (EST_UPD_MAX1),1 (EST_UPD_MAX2),2 (EST_UPD_MAX4),3 (EST_UPD_MAX8),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "CALRC2_CAL_FREQ_PSLP"
      sgroup "CALRC2_CAL_FREQ_PSLP (at 0x5e55)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CAL_FREQ_PSLP                            = "
    tree.end
    tree "CALRC2_CAL_FREQ_PRTC"
      sgroup "CALRC2_CAL_FREQ_PRTC (at 0x5e56)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CAL_FREQ_RTC                             = "
    tree.end
    tree "CALRC2_CAL_DUR_PSLP"
      sgroup "CALRC2_CAL_DUR_PSLP (at 0x5e57)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CAL_DUR_PSLP                             = " "0 (reserved),1 (reserved),2 (CAL_DUR_MAX4),3 (CAL_DUR_MAX8)"
    tree.end
    tree "CALRC2_CAL_DUR_PRTC"
      sgroup "CALRC2_CAL_DUR_PRTC (at 0x5e58)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CAL_DUR_PRTC                             = " "0 (reserved),1 (reserved),2 (CAL_DUR_MAX4),3 (CAL_DUR_MAX8)"
    tree.end
    tree "CALRC2_DRIFT_LMT_PSLP"
      sgroup "CALRC2_DRIFT_LMT_PSLP (at 0x5e59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DRIFT_LMT_PSLP                           = "
    tree.end
    tree "CALRC2_DRIFT_LMT_PRTC"
      sgroup "CALRC2_DRIFT_LMT_PRTC (at 0x5e5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DRIFT_LMT_PRTC                           = "
    tree.end
    tree "CALRC2_SLOPE_LMT_PSLP"
      sgroup "CALRC2_SLOPE_LMT_PSLP (at 0x5e5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SLOPE_LMT_PSLP                           = "
    tree.end
    tree "CALRC2_SLOPE_LMT_PRTC"
      sgroup "CALRC2_SLOPE_LMT_PRTC (at 0x5e5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SLOPE_LMT_PRTC                           = "
    tree.end
    tree "CALRC2_XOCNT_LMT_PSLP"
      sgroup "CALRC2_XOCNT_LMT_PSLP (at 0x5e5d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   XOCNT_LMT_PSLP                           = "
    tree.end
    tree "CALRC2_XOCNT_LMT_PRTC"
      sgroup "CALRC2_XOCNT_LMT_PRTC (at 0x5e5e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   XOCNT_LMT_PRTC                           = "
    tree.end
    tree "CALRC2_LFRC_OFFSET"
      sgroup "CALRC2_LFRC_OFFSET (at 0x5e5f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e5f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LFRC_OFFSET                              = "
    tree.end
    tree "CALRC2_XOCNT_OFFSET_PSLP"
      sgroup "CALRC2_XOCNT_OFFSET_PSLP (at 0x5e60)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XOCNT_OFFSET_PSLP                        = "
    tree.end
    tree "CALRC2_XOCNT_OFFSET_PRTC"
      sgroup "CALRC2_XOCNT_OFFSET_PRTC (at 0x5e61)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XOCNT_OFFSET_PRTC                        = "
    tree.end
    tree "CALRC2_CAL_XOTIMER_PSLP_MSB"
      sgroup "CALRC2_CAL_XOTIMER_PSLP_MSB (at 0x5e62)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CAL_TIMER_PSLP_MSB                       = "
    tree.end
    tree "CALRC2_CAL_XOTIMER_PSLP_LSB"
      sgroup "CALRC2_CAL_XOTIMER_PSLP_LSB (at 0x5e63)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER_PSLP_LSB                       = "
    tree.end
    tree "CALRC2_CAL_XOTIMER_PRTC_MSB"
      sgroup "CALRC2_CAL_XOTIMER_PRTC_MSB (at 0x5e64)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CAL_TIMER_PRTC_MSB                       = "
    tree.end
    tree "CALRC2_CAL_XOTIMER_PRTC_LSB"
      sgroup "CALRC2_CAL_XOTIMER_PRTC_LSB (at 0x5e65)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER_PRTC_LSB                       = "
    tree.end
    tree "CALRC2_LFRC_DRIFT_BATT_EN"
      sgroup "CALRC2_LFRC_DRIFT_BATT_EN (at 0x5e66)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "CALRC2_PMIC_STATE"
      sgroup "CALRC2_PMIC_STATE (at 0x5e67)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PMIC_STATE                               = " "0 (PMIC_OFF),1 (PMIC_ON)"
    tree.end
    tree "CALRC2_FORCE_XODIV"
      sgroup "CALRC2_FORCE_XODIV (at 0x5e68)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_XODIV                              = " "0 (NO_FORCE),1 (FORCE)"
    tree.end
    tree "CALRC2_CALRC_ENABLE"
      sgroup "CALRC2_CALRC_ENABLE (at 0x5e69)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805e690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
    tree.end
    tree "CALRC2_SEC_ACCESS"
      sgroup "CALRC2_SEC_ACCESS (at 0x5ed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CALRC2_PERPH_RESET_CTL2"
      sgroup "CALRC2_PERPH_RESET_CTL2 (at 0x5ed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CALRC2_PERPH_RESET_CTL3"
      sgroup "CALRC2_PERPH_RESET_CTL3 (at 0x5eda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CALRC2_PERPH_RESET_CTL4"
      sgroup "CALRC2_PERPH_RESET_CTL4 (at 0x5edb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CALRC2_PERPH_RESET_CTL5"
      sgroup "CALRC2_PERPH_RESET_CTL5 (at 0x5edc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805edc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5edc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CALRC2_PERPH_RESET_CTL6"
      sgroup "CALRC2_PERPH_RESET_CTL6 (at 0x5edd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805edd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5edd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CALRC2_CALRC_CLK_TEST"
      sgroup "CALRC2_CALRC_CLK_TEST (at 0x5ee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805ee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CALRC_XO_FREQ                            = " "0 (XO19M2HZ),1 (XO38M4HZ)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_CLKTEST_CCELL                      = " "0 (LFRC_AS_CLK),1 (DTEST_IN_AS_CLK)"
    tree.end
    tree "CALRC2_CALRC_CLK_TEST1"
      sgroup "CALRC2_CALRC_CLK_TEST1 (at 0x5ee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805ee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_CLKTEST_DVDD                       = " "0 (LFRC_AS_CLK),1 (DTEST_IN_AS_CLK)"
    tree.end
    tree "CALRC2_TEST1"
      sgroup "CALRC2_TEST1 (at 0x5ee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        set &access:&cmd_addr %l 0x805ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CALRC_DTEST_SEL                          = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HFRC_OK                                  = " "0 (HFRC_OFF),1 (HFRC_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   IDSS_TIMER_EXPIRED                       = " "0 (IDSS_TIMER_NOT_EXPIRED),1 (IDSS_TIMER_EXPIRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HF_GP_SEL_STATUS                         = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HF_SMPS_SEL_STATUS                       = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SLP_CLK_PAD_VREG_OK                      = " "0 (SLP_CLK_PAD_VREG_NOT_OK),1 (SLP_CLK_PAD_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (XO_32K),1 (EXT_32K),2 (CALRC1),3 (LFRC),4 (RC19M_DIV),5 (XO19M_DIV),6 (CALRC2),7 (RESERVED_7)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_RT_STS                   = " "0 (CLK32K_NOT_HALT),1 (CLK32K_HALT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_RT_STS                       = " "0 (XO_NOT_HALT),1 (XO_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CLK32K_INT_MID_SEL                       = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XO_INT_MID_SEL                           = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_INT_PRIORITY                      = " "0 (SR),1 (A)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_INT_PRIORITY                          = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (SMPS_CLK_HFRC),2 (SMPS_CLK_XO),3 (SMPS_CLK_BASE_ON_HALT_B)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_SEL                                = " "0 (GP_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (GP_CLK_HFRC),2 (GP_CLK_XO),3 (GP_CLK_BASE_ON_HALT_B)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0 (ALT_SC_DIVIDER_DIS),1 (ALT_SC_DIVIDER_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT32K_CLK_SEL                           = " "0 (CALRC),1 (EXT32K)"
    tree.end
    tree "CLK_DIST_CLK_CTL5"
      sgroup "CLK_DIST_CLK_CTL5 (at 0x5944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_32K_SEL                              = " "0 (FOLLOW_32K_HALT),1 (LFRC_AON),2 (CLK_32K_SOURCE),3 (reserved)"
    tree.end
    tree "CLK_DIST_XO_HALT_CTL"
      sgroup "CLK_DIST_XO_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_XO_HALT                        = " "0 (NOT_FOLLOW_HW_XO_HALT),1 (FOLLOW_HW_XO_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO_HALT                            = " "0 (XO_HALT_NOT_FORCED),1 (XO_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO_HALT                             = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_HFRC_CTL"
      sgroup "CLK_DIST_HFRC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_HFRC_OSC_ON                        = " "0 (HFRC_NOT_FORCED),1 (HFRC_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HFRC_OSC_HW_CTL                          = " "0 (HFRC_NOT_FOLLOW_HW_DEMAND),1 (HFRC_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_CLK32K_HALT_CTL"
      sgroup "CLK_DIST_CLK32K_HALT_CTL (at 0x5947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_CLK32K_HALT                    = " "0 (NOT_FOLLOW_HW_CLK32K_HALT),1 (FOLLOW_HW_CLK32K_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_CLK32K_HALT                        = " "0 (CLK32K_HALT_NOT_FORCED),1 (CLK32K_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_CLK32K_HALT                         = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_CLKS_XOTIMER_MSB"
      sgroup "CLK_DIST_CLKS_XOTIMER_MSB (at 0x594b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMER_MSB                                = "
    tree.end
    tree "CLK_DIST_CLKS_XOTIMER_LSB"
      sgroup "CLK_DIST_CLKS_XOTIMER_LSB (at 0x594c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_LSB                                = "
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TEST_VAL                     = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (HF_CLK),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_HFRC_TRIM"
      sgroup "CLK_DIST_HFRC_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_LFRC_CALRC_TRIM"
      sgroup "CLK_DIST_LFRC_CALRC_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LFRC_CALRC_TRIM                          = "
    tree.end
    tree "CLK_DIST_LFRC_AON_TRIM"
      sgroup "CLK_DIST_LFRC_AON_TRIM (at 0x59f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LFRC_AON_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      sgroup "DIV_CLK1_REVISION1 (at 0x5b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      sgroup "DIV_CLK1_REVISION2 (at 0x5b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      sgroup "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      sgroup "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      sgroup "DIV_CLK1_STATUS1 (at 0x5b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      sgroup "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1_0),1 (XO_DIV1),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      sgroup "DIV_CLK1_EN_CTL (at 0x5b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      sgroup "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      sgroup "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      sgroup "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      sgroup "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      sgroup "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
  tree.end
tree.end
tree "DIV_CLK2"
  tree "DIV_CLK2"
    tree "DIV_CLK2_REVISION1"
      sgroup "DIV_CLK2_REVISION1 (at 0x5c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK2_REVISION2"
      sgroup "DIV_CLK2_REVISION2 (at 0x5c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK2_PERPH_TYPE"
      sgroup "DIV_CLK2_PERPH_TYPE (at 0x5c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK2_PERPH_SUBTYPE"
      sgroup "DIV_CLK2_PERPH_SUBTYPE (at 0x5c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK2_STATUS1"
      sgroup "DIV_CLK2_STATUS1 (at 0x5c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK2_DIV_CTL1"
      sgroup "DIV_CLK2_DIV_CTL1 (at 0x5c43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1_0),1 (XO_DIV1),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK2_EN_CTL"
      sgroup "DIV_CLK2_EN_CTL (at 0x5c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK2_SEC_ACCESS"
      sgroup "DIV_CLK2_SEC_ACCESS (at 0x5cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL1"
      sgroup "DIV_CLK2_PERPH_RESET_CTL1 (at 0x5cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL2"
      sgroup "DIV_CLK2_PERPH_RESET_CTL2 (at 0x5cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL3"
      sgroup "DIV_CLK2_PERPH_RESET_CTL3 (at 0x5cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL4"
      sgroup "DIV_CLK2_PERPH_RESET_CTL4 (at 0x5cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
  tree.end
tree.end
tree "DIV_CLK3"
  tree "DIV_CLK3"
    tree "DIV_CLK3_REVISION1"
      sgroup "DIV_CLK3_REVISION1 (at 0x5d00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK3_REVISION2"
      sgroup "DIV_CLK3_REVISION2 (at 0x5d01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK3_PERPH_TYPE"
      sgroup "DIV_CLK3_PERPH_TYPE (at 0x5d04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK3_PERPH_SUBTYPE"
      sgroup "DIV_CLK3_PERPH_SUBTYPE (at 0x5d05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK3_STATUS1"
      sgroup "DIV_CLK3_STATUS1 (at 0x5d08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK3_DIV_CTL1"
      sgroup "DIV_CLK3_DIV_CTL1 (at 0x5d43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1_0),1 (XO_DIV1),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK3_EN_CTL"
      sgroup "DIV_CLK3_EN_CTL (at 0x5d46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK3_SEC_ACCESS"
      sgroup "DIV_CLK3_SEC_ACCESS (at 0x5dd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL1"
      sgroup "DIV_CLK3_PERPH_RESET_CTL1 (at 0x5dd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL2"
      sgroup "DIV_CLK3_PERPH_RESET_CTL2 (at 0x5dd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL3"
      sgroup "DIV_CLK3_PERPH_RESET_CTL3 (at 0x5dda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL4"
      sgroup "DIV_CLK3_PERPH_RESET_CTL4 (at 0x5ddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO1_DIG_IN_DTEST_SEL"
      sgroup "GPIO1_DIG_IN_DTEST_SEL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO1_DIG_OUT_SOURCE_CTL (at 0xc044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_OUT_DRV_CTL"
      sgroup "GPIO1_DIG_OUT_DRV_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_ANA_PASS_THRU_SEL"
      sgroup "GPIO1_ANA_PASS_THRU_SEL (at 0xc04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO2_DIG_IN_DTEST_SEL"
      sgroup "GPIO2_DIG_IN_DTEST_SEL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO2_DIG_OUT_SOURCE_CTL (at 0xc144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_OUT_DRV_CTL"
      sgroup "GPIO2_DIG_OUT_DRV_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_ANA_PASS_THRU_SEL"
      sgroup "GPIO2_ANA_PASS_THRU_SEL (at 0xc14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      sgroup "GPIO3_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      sgroup "GPIO3_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      sgroup "GPIO3_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      sgroup "GPIO3_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      sgroup "GPIO3_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      sgroup "GPIO3_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      sgroup "GPIO3_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      sgroup "GPIO3_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      sgroup "GPIO3_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      sgroup "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      sgroup "GPIO3_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      sgroup "GPIO3_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      sgroup "GPIO3_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      sgroup "GPIO3_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      sgroup "GPIO3_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      sgroup "GPIO3_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      sgroup "GPIO3_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      sgroup "GPIO3_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      sgroup "GPIO3_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      sgroup "GPIO3_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      sgroup "GPIO3_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO3_DIG_IN_DTEST_SEL"
      sgroup "GPIO3_DIG_IN_DTEST_SEL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO3_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO3_DIG_OUT_SOURCE_CTL (at 0xc244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_OUT_DRV_CTL"
      sgroup "GPIO3_DIG_OUT_DRV_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO3_EN_CTL"
      sgroup "GPIO3_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_ANA_PASS_THRU_SEL"
      sgroup "GPIO3_ANA_PASS_THRU_SEL (at 0xc24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      sgroup "GPIO3_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      sgroup "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      sgroup "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      sgroup "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      sgroup "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      sgroup "GPIO4_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      sgroup "GPIO4_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      sgroup "GPIO4_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      sgroup "GPIO4_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      sgroup "GPIO4_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      sgroup "GPIO4_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      sgroup "GPIO4_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      sgroup "GPIO4_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      sgroup "GPIO4_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      sgroup "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      sgroup "GPIO4_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      sgroup "GPIO4_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      sgroup "GPIO4_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      sgroup "GPIO4_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      sgroup "GPIO4_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      sgroup "GPIO4_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      sgroup "GPIO4_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      sgroup "GPIO4_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      sgroup "GPIO4_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      sgroup "GPIO4_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      sgroup "GPIO4_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO4_DIG_IN_DTEST_SEL"
      sgroup "GPIO4_DIG_IN_DTEST_SEL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO4_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO4_DIG_OUT_SOURCE_CTL (at 0xc344)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_OUT_DRV_CTL"
      sgroup "GPIO4_DIG_OUT_DRV_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO4_EN_CTL"
      sgroup "GPIO4_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_ANA_PASS_THRU_SEL"
      sgroup "GPIO4_ANA_PASS_THRU_SEL (at 0xc34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      sgroup "GPIO4_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      sgroup "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      sgroup "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      sgroup "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      sgroup "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO_RF"
  tree "LDO_RF"
    tree "LDO_RF_REVISION1"
      sgroup "LDO_RF_REVISION1 (at 0x14100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_RF_REVISION2"
      sgroup "LDO_RF_REVISION2 (at 0x14101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_RF_REVISION3"
      sgroup "LDO_RF_REVISION3 (at 0x14102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_RF_REVISION4"
      sgroup "LDO_RF_REVISION4 (at 0x14103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_RF_PERPH_TYPE"
      sgroup "LDO_RF_PERPH_TYPE (at 0x14104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_RF_PERPH_SUBTYPE"
      sgroup "LDO_RF_PERPH_SUBTYPE (at 0x14105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_RF_STATUS1"
      sgroup "LDO_RF_STATUS1 (at 0x14108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_RF_VOLTAGE_CTL1"
      sgroup "LDO_RF_VOLTAGE_CTL1 (at 0x14140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_RF_VOLTAGE_CTL2"
      sgroup "LDO_RF_VOLTAGE_CTL2 (at 0x14141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET                                     = "
    tree.end
    tree "LDO_RF_EN_CTL"
      sgroup "LDO_RF_EN_CTL (at 0x14146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_RF_PD_CTL"
      sgroup "LDO_RF_PD_CTL (at 0x14148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO_RF_SEC_ACCESS"
      sgroup "LDO_RF_SEC_ACCESS (at 0x141d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_RF_PERPH_RESET_CTL1"
      sgroup "LDO_RF_PERPH_RESET_CTL1 (at 0x141d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_RF_PERPH_RESET_CTL2"
      sgroup "LDO_RF_PERPH_RESET_CTL2 (at 0x141d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_RF_PERPH_RESET_CTL3"
      sgroup "LDO_RF_PERPH_RESET_CTL3 (at 0x141da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_RF_PERPH_RESET_CTL4"
      sgroup "LDO_RF_PERPH_RESET_CTL4 (at 0x141db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_RF_TEST1"
      sgroup "LDO_RF_TEST1 (at 0x141e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO_XO"
  tree "LDO_XO"
    tree "LDO_XO_REVISION1"
      sgroup "LDO_XO_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION2"
      sgroup "LDO_XO_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_XO_REVISION3"
      sgroup "LDO_XO_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION4"
      sgroup "LDO_XO_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_XO_PERPH_TYPE"
      sgroup "LDO_XO_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_XO_PERPH_SUBTYPE"
      sgroup "LDO_XO_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_XO_STATUS1"
      sgroup "LDO_XO_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL1"
      sgroup "LDO_XO_VOLTAGE_CTL1 (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL2"
      sgroup "LDO_XO_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET                                     = "
    tree.end
    tree "LDO_XO_EN_CTL"
      sgroup "LDO_XO_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_XO_PD_CTL"
      sgroup "LDO_XO_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO_XO_SEC_ACCESS"
      sgroup "LDO_XO_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL1"
      sgroup "LDO_XO_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL2"
      sgroup "LDO_XO_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL3"
      sgroup "LDO_XO_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL4"
      sgroup "LDO_XO_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_XO_TEST1"
      sgroup "LDO_XO_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LN_BB_CLK"
  tree "LN_BB_CLK"
    tree "LN_BB_CLK_REVISION1"
      sgroup "LN_BB_CLK_REVISION1 (at 0x5800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION2"
      sgroup "LN_BB_CLK_REVISION2 (at 0x5801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION3"
      sgroup "LN_BB_CLK_REVISION3 (at 0x5802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION4"
      sgroup "LN_BB_CLK_REVISION4 (at 0x5803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_PERPH_TYPE"
      sgroup "LN_BB_CLK_PERPH_TYPE (at 0x5804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LN_BB_CLK_PERPH_SUBTYPE"
      sgroup "LN_BB_CLK_PERPH_SUBTYPE (at 0x5805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LN_BB_CLK_STATUS1"
      sgroup "LN_BB_CLK_STATUS1 (at 0x5808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "LN_BB_CLK_EDGE_CTL1"
      sgroup "LN_BB_CLK_EDGE_CTL1 (at 0x5843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "LN_BB_CLK_DRV_CTL1"
      sgroup "LN_BB_CLK_DRV_CTL1 (at 0x5844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_EN_CTL"
      sgroup "LN_BB_CLK_EN_CTL (at 0x5846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_PD_CTL"
      sgroup "LN_BB_CLK_PD_CTL (at 0x5848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "LN_BB_CLK_TIMER"
      sgroup "LN_BB_CLK_TIMER (at 0x584c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80584c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x584c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DELAY                                    = "
    tree.end
    tree "LN_BB_CLK_SEC_ACCESS"
      sgroup "LN_BB_CLK_SEC_ACCESS (at 0x58d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL1"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL1 (at 0x58d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL2"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL2 (at 0x58d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL3"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL3 (at 0x58da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL4"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL4 (at 0x58db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "LN_BB_CLK_TEST1"
      sgroup "LN_BB_CLK_TEST1 (at 0x58e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS"
      sgroup "MISC_STATUS (at 0x908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VDD_ACTIVE_OK                            = " "0 (VDD_ACTIVE_VOLTAGE_LOW),1 (VDD_ACTIVE_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_IO_OK                                = " "0 (VDD_IO_VOLTAGE_LOW),1 (VDD_IO_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VDD_PADIO_OK                             = " "0 (VDD_PADIO_VOLTAGE_LOW),1 (VDD_PADIO_OK)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   DTEST                                    = "
    tree.end
    tree "MISC_FORCE_VDD_IO_OK"
      sgroup "MISC_FORCE_VDD_IO_OK (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_OK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW                                = " "0, 1"
    tree.end
    tree "MISC_FORCE_VDD_ACTIVE_OK"
      sgroup "MISC_FORCE_VDD_ACTIVE_OK (at 0x90a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80090a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x90a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_OK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW                                = " "0, 1"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
    tree.end
    tree "MISC_ANA_BUF_EN_CTL"
      sgroup "MISC_ANA_BUF_EN_CTL (at 0x9e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0, 1"
    tree.end
    tree "MISC_ANA_IN_SEL"
      sgroup "MISC_ANA_IN_SEL (at 0x9e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_OUT_SEL"
      sgroup "MISC_ANA_OUT_SEL (at 0x9e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0, 1, 2, 3"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_RAM_CFG1"
      sgroup "PBS_CORE_RAM_CFG1 (at 0x70a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG1"
      sgroup "PBS_CORE_NVM_CFG1 (at 0x70a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG2"
      sgroup "PBS_CORE_NVM_CFG2 (at 0x70a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPE                                     = " "0 (OTP),1 (ROM)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACCESS                                   = " "0 (WRITE_1200US_READ_800NS_INSTR_PR_1510NS),1 (WRITE_600US_READ_400NS_INSTR_PR_940NS),2 (WRITE_300US_READ_200NS_INSTR_PR_730NS),3 (reserved)"
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "PBS_CORE_RAM_READ_MARGIN"
      sgroup "PBS_CORE_RAM_READ_MARGIN (at 0x70e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RM                                       = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   POFF_FAULT_OCCURRED                      = " "0 (NO_FAULT),1 (FAULT_OCCURRED)"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL"
      sgroup "PON_RESERVED_FAULT_RESET_CTL (at 0x868)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL2"
      sgroup "PON_RESERVED_FAULT_RESET_CTL2 (at 0x869)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_DEBOUNCE                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_DEBOUNCE_DLY                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_UVLO_DLY                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   AVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_DVDD_VPH"
      sgroup "PON_DVDD_VPH (at 0x88b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_PON_DVDDREG),3 (DVDD_SRC_FROM_PON_DVDDREG1)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_DEBUG_CTL"
      sgroup "PON_DEBUG_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_50K)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      sgroup "PON_DEBUG_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_DVDD_2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST2_DVDD_INT                          = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      sgroup "PON_PON_CNTL_3_TRIM (at 0x8f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_4_TRIM"
      sgroup "PON_PON_CNTL_4_TRIM (at 0x8f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
  tree.end
tree.end
tree "REVID1"
  tree "REVID1"
    tree "REVID1_REVISION1"
      sgroup "REVID1_REVISION1 (at 0x10100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID1_REVISION2"
      sgroup "REVID1_REVISION2 (at 0x10101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID1_REVISION3"
      sgroup "REVID1_REVISION3 (at 0x10102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID1_REVISION4"
      sgroup "REVID1_REVISION4 (at 0x10103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID1_PERPH_TYPE"
      sgroup "REVID1_PERPH_TYPE (at 0x10104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID1_PERPH_SUBTYPE"
      sgroup "REVID1_PERPH_SUBTYPE (at 0x10105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID1_SEC_ACCESS"
      sgroup "REVID1_SEC_ACCESS (at 0x101d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      sgroup "RF_CLK1_REVISION1 (at 0x5400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      sgroup "RF_CLK1_REVISION2 (at 0x5401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      sgroup "RF_CLK1_REVISION3 (at 0x5402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      sgroup "RF_CLK1_REVISION4 (at 0x5403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      sgroup "RF_CLK1_PERPH_TYPE (at 0x5404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      sgroup "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      sgroup "RF_CLK1_STATUS1 (at 0x5408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK1_EDGE_CTL1"
      sgroup "RF_CLK1_EDGE_CTL1 (at 0x5443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      sgroup "RF_CLK1_DRV_CTL1 (at 0x5444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_EN_CTL"
      sgroup "RF_CLK1_EN_CTL (at 0x5446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      sgroup "RF_CLK1_PD_CTL (at 0x5448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      sgroup "RF_CLK1_SEC_ACCESS (at 0x54d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      sgroup "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      sgroup "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      sgroup "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      sgroup "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RF_CLK1_TEST1"
      sgroup "RF_CLK1_TEST1 (at 0x54e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_DISABLE),1 (ATEST_ENABLE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      sgroup "RF_CLK2_REVISION1 (at 0x5500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      sgroup "RF_CLK2_REVISION2 (at 0x5501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      sgroup "RF_CLK2_REVISION3 (at 0x5502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      sgroup "RF_CLK2_REVISION4 (at 0x5503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      sgroup "RF_CLK2_PERPH_TYPE (at 0x5504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      sgroup "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      sgroup "RF_CLK2_STATUS1 (at 0x5508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK2_EDGE_CTL1"
      sgroup "RF_CLK2_EDGE_CTL1 (at 0x5543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      sgroup "RF_CLK2_DRV_CTL1 (at 0x5544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_EN_CTL"
      sgroup "RF_CLK2_EN_CTL (at 0x5546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      sgroup "RF_CLK2_PD_CTL (at 0x5548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      sgroup "RF_CLK2_SEC_ACCESS (at 0x55d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      sgroup "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      sgroup "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      sgroup "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      sgroup "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RF_CLK2_TEST1"
      sgroup "RF_CLK2_TEST1 (at 0x55e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_DISABLE),1 (ATEST_ENABLE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      sgroup "RTC_ALARM_REVISION1 (at 0x6100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      sgroup "RTC_ALARM_REVISION2 (at 0x6101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      sgroup "RTC_ALARM_PERPH_TYPE (at 0x6104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      sgroup "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      sgroup "RTC_ALARM_STATUS1 (at 0x6108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      sgroup "RTC_ALARM_INT_RT_STS (at 0x6110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      sgroup "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      sgroup "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      sgroup "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      sgroup "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      sgroup "RTC_ALARM_INT_EN_SET (at 0x6115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      sgroup "RTC_ALARM_INT_EN_CLR (at 0x6116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      sgroup "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      sgroup "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      sgroup "RTC_ALARM_INT_MID_SEL (at 0x611a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      sgroup "RTC_ALARM_INT_PRIORITY (at 0x611b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      sgroup "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      sgroup "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      sgroup "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      sgroup "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      sgroup "RTC_ALARM_EN_CTL1 (at 0x6146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      sgroup "RTC_ALARM_ALARM_CLR (at 0x6148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      sgroup "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      sgroup "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      sgroup "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      sgroup "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      sgroup "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      sgroup "RTC_ALARM_INT_TEST1 (at 0x61e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      sgroup "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_RW"
  tree "RTC_RW"
    tree "RTC_RW_REVISION1"
      sgroup "RTC_RW_REVISION1 (at 0x6000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_RW_REVISION2"
      sgroup "RTC_RW_REVISION2 (at 0x6001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_RW_PERPH_TYPE"
      sgroup "RTC_RW_PERPH_TYPE (at 0x6004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_RW_PERPH_SUBTYPE"
      sgroup "RTC_RW_PERPH_SUBTYPE (at 0x6005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_RW_STATUS1"
      sgroup "RTC_RW_STATUS1 (at 0x6008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_RW_INT_RT_STS"
      sgroup "RTC_RW_INT_RT_STS (at 0x6010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_RW_INT_SET_TYPE"
      sgroup "RTC_RW_INT_SET_TYPE (at 0x6011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_RW_INT_POLARITY_HIGH"
      sgroup "RTC_RW_INT_POLARITY_HIGH (at 0x6012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_POLARITY_LOW"
      sgroup "RTC_RW_INT_POLARITY_LOW (at 0x6013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_LATCHED_CLR"
      sgroup "RTC_RW_INT_LATCHED_CLR (at 0x6014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_EN_SET"
      sgroup "RTC_RW_INT_EN_SET (at 0x6015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_RW_INT_EN_CLR"
      sgroup "RTC_RW_INT_EN_CLR (at 0x6016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_LATCHED_STS"
      sgroup "RTC_RW_INT_LATCHED_STS (at 0x6018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_RW_INT_PENDING_STS"
      sgroup "RTC_RW_INT_PENDING_STS (at 0x6019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_RW_INT_MID_SEL"
      sgroup "RTC_RW_INT_MID_SEL (at 0x601a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_RW_INT_PRIORITY"
      sgroup "RTC_RW_INT_PRIORITY (at 0x601b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_RW_WDATA0"
      sgroup "RTC_RW_WDATA0 (at 0x6040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_RW_WDATA1"
      sgroup "RTC_RW_WDATA1 (at 0x6041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_RW_WDATA2"
      sgroup "RTC_RW_WDATA2 (at 0x6042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_RW_WDATA3"
      sgroup "RTC_RW_WDATA3 (at 0x6043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_RW_TIME_ADJ"
      sgroup "RTC_RW_TIME_ADJ (at 0x6044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_RW_EN_CTL1"
      sgroup "RTC_RW_EN_CTL1 (at 0x6046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_RW_RDATA0"
      sgroup "RTC_RW_RDATA0 (at 0x6048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_RW_RDATA1"
      sgroup "RTC_RW_RDATA1 (at 0x6049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_RW_RDATA2"
      sgroup "RTC_RW_RDATA2 (at 0x604a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_RW_RDATA3"
      sgroup "RTC_RW_RDATA3 (at 0x604b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_RW_SEC_ACCESS"
      sgroup "RTC_RW_SEC_ACCESS (at 0x60d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL1"
      sgroup "RTC_RW_PERPH_RESET_CTL1 (at 0x60d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL2"
      sgroup "RTC_RW_PERPH_RESET_CTL2 (at 0x60d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL3"
      sgroup "RTC_RW_PERPH_RESET_CTL3 (at 0x60da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL4"
      sgroup "RTC_RW_PERPH_RESET_CTL4 (at 0x60db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_RW_INT_TEST1"
      sgroup "RTC_RW_INT_TEST1 (at 0x60e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_RW_INT_TEST_VAL"
      sgroup "RTC_RW_INT_TEST_VAL (at 0x60e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_RW_TEST1"
      sgroup "RTC_RW_TEST1 (at 0x60e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      sgroup "RTC_TIMER_REVISION1 (at 0x6200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      sgroup "RTC_TIMER_REVISION2 (at 0x6201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      sgroup "RTC_TIMER_PERPH_TYPE (at 0x6204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      sgroup "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      sgroup "RTC_TIMER_STATUS1 (at 0x6208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      sgroup "RTC_TIMER_INT_RT_STS (at 0x6210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      sgroup "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      sgroup "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      sgroup "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      sgroup "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      sgroup "RTC_TIMER_INT_EN_SET (at 0x6215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      sgroup "RTC_TIMER_INT_EN_CLR (at 0x6216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      sgroup "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      sgroup "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      sgroup "RTC_TIMER_INT_MID_SEL (at 0x621a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      sgroup "RTC_TIMER_INT_PRIORITY (at 0x621b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      sgroup "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      sgroup "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      sgroup "RTC_TIMER_TIMER_MODE (at 0x6245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      sgroup "RTC_TIMER_EN_CTL (at 0x6246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      sgroup "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      sgroup "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      sgroup "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      sgroup "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      sgroup "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      sgroup "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      sgroup "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      sgroup "RTC_TIMER_INT_TEST1 (at 0x62e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      sgroup "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      sgroup "SLEEP_CLK1_REVISION1 (at 0x5a00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      sgroup "SLEEP_CLK1_REVISION2 (at 0x5a01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      sgroup "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      sgroup "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      sgroup "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      sgroup "SLEEP_CLK1_EN_CTL (at 0x5a46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_SLPCLK_PAD_EN                      = " "0 (NOT_FORCE_SLPCLK_PAD_EN),1 (FORCE_SLPCLK_PAD_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLOW_HW_SLPCLK_PAD_EN                   = " "0 (NOT_FOLLOW_HW_SLPCLK_PAD_EN),1 (FOLLOW_HW_SLPCLK_PAD_EN)"
    tree.end
    tree "SLEEP_CLK1_SMPL_CTL1"
      sgroup "SLEEP_CLK1_SMPL_CTL1 (at 0x5a48)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SMPL_DELAY                               = " "0 (HALF_SEC),1 (ONE_SEC),2 (ONEANDHALF_SEC),3 (TWO_SEC)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      sgroup "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EXT32K_EN                                = " "0 (EXT32K_DISABLED),1 (EXT32K_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_LFRC_CALRC_CTL"
      sgroup "SLEEP_CLK1_LFRC_CALRC_CTL (at 0x5a57)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLKS_XVDD_BLEED                          = " "0 (NA_0),1 (NA_200),2 (reserved),3 (NA_600),4 (reserved),5 (reserved),6 (reserved),7 (NA_1600)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      sgroup "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      sgroup "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      sgroup "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      sgroup "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      sgroup "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      sgroup "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805add0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5add0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      sgroup "SLEEP_CLK1_TEST1 (at 0x5ae2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMPL_TRIGGER_SEL                         = " "0 (HIZ),1 (CONNECT_TO_DTEST)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OSC_VDD_ATEST_EN                         = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_OK                                    = " "0 (XO_OFF),1 (XO_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_SLEEP_B                               = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LNBBCLK_DIV2_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO_NOT_FORCED),1 (XO_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DELAY                                    = "
    tree.end
    tree "XO_SPARE1"
      sgroup "XO_SPARE1 (at 0x5051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_SPARE2"
      sgroup "XO_SPARE2 (at 0x5052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_SPARE3"
      sgroup "XO_SPARE3 (at 0x5053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_XO_STEPPER"
      sgroup "XO_XO_STEPPER (at 0x505a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      sgroup "XO_XO_ADJ_FINE (at 0x505c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_ICTL"
      sgroup "XO_ICTL (at 0x505e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MISSION                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLEEP                                    = "
    tree.end
    tree "XO_SEC_ACCESS"
      sgroup "XO_SEC_ACCESS (at 0x50d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      sgroup "XO_PERPH_RESET_CTL2 (at 0x50d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      sgroup "XO_PERPH_RESET_CTL3 (at 0x50da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      sgroup "XO_PERPH_RESET_CTL4 (at 0x50db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "XO_TEST1"
      sgroup "XO_TEST1 (at 0x50e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (RAW_XO_CLK),2 (OUTBUFF_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      sgroup "XO_TEST2 (at 0x50e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (DRIVE_RF_NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (RF_NORMAL),1 (RF_DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (DRIVE_BB_NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (BB_NORMAL),1 (BB_DISABLED),2 (reserved),3 (reserved)"
    tree.end
  tree.end
tree.end

