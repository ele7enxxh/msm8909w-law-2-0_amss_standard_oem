        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_CHGR_PERPH_SUBTYPE"
      sgroup "SMBCHGL_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_CHGR_CHG_OPTION"
      sgroup "SMBCHGL_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_VBAT_STATUS"
      sgroup "SMBCHGL_CHGR_VBAT_STATUS (at 0x100b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ABOVE_VBAT_WEAK                          = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_FV_STS"
      sgroup "SMBCHGL_CHGR_FV_STS (at 0x100c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FV_STS_EXTRA                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_STS                                   = "
    tree.end
    tree "SMBCHGL_CHGR_ICHG_STS"
      sgroup "SMBCHGL_CHGR_ICHG_STS (at 0x100d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PCC_STS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC_STS                                  = "
    tree.end
    tree "SMBCHGL_CHGR_CHGR_STS"
      sgroup "SMBCHGL_CHGR_CHGR_STS (at 0x100e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_I_STS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_FV_COMP_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DONE_STS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATV_LT_2V                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOLD_OFF_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CHARGING_STS                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_RT_STS"
      sgroup "SMBCHGL_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_RT_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_RT_STS                        = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_SET_TYPE"
      sgroup "SMBCHGL_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_TYPE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_TYPE                          = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_HIGH            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_HIGH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_HIGH                          = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_POLARITY_LOW"
      sgroup "SMBCHGL_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LOW             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LOW                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LOW                           = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_LATCHED_CLR"
      sgroup "SMBCHGL_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_CLR     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_EN_SET"
      sgroup "SMBCHGL_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_SET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_SET             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_SET                        = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_EN_CLR"
      sgroup "SMBCHGL_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_CLR                        = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_LATCHED_STS"
      sgroup "SMBCHGL_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_PENDING_STS"
      sgroup "SMBCHGL_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_PENDING_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_PENDING_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_MID_SEL"
      sgroup "SMBCHGL_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_CHGR_INT_PRIORITY"
      sgroup "SMBCHGL_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_SEC_ACCESS"
      sgroup "SMBCHGL_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_CHGR_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_SPARE"
      sgroup "SMBCHGL_CHGR_SPARE (at 0x10df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_CHGR_INT_TEST1"
      sgroup "SMBCHGL_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_INT_TEST_VAL"
      sgroup "SMBCHGL_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_INT_VAL          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_INT_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_INT_VAL         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_INT_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_INT_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_INT_VAL                       = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_TEST_MODE1"
      sgroup "SMBCHGL_CHGR_TEST_MODE1 (at 0x10e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_CHG_7_0                               = "
    tree.end
    tree "SMBCHGL_CHGR_TEST_MODE2"
      sgroup "SMBCHGL_CHGR_TEST_MODE2 (at 0x10e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TM_CHG_12_8                              = "
    tree.end
    tree "SMBCHGL_CHGR_TEST_MODE3"
      sgroup "SMBCHGL_CHGR_TEST_MODE3 (at 0x10e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_TLOOP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NGATE                                 = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_TEST_MODE4"
      sgroup "SMBCHGL_CHGR_TEST_MODE4 (at 0x10e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_START_COPY                          = " "0, 1"
    tree.end
    tree "SMBCHGL_CHGR_TEST_15_8"
      sgroup "SMBCHGL_CHGR_TEST_15_8 (at 0x10e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_15_8                                = "
    tree.end
    tree "SMBCHGL_CHGR_TEST_7_0"
      sgroup "SMBCHGL_CHGR_TEST_7_0 (at 0x10e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_7_0                                 = "
    tree.end
    tree "SMBCHGL_CHGR_TRIM_NUM"
      sgroup "SMBCHGL_CHGR_TRIM_NUM (at 0x10f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_CHGR_PCC_CFG"
      sgroup "SMBCHGL_CHGR_PCC_CFG (at 0x10f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PCC                                      = " "0 (PCC_100MA),1 (PCC_150MA),2 (PCC_200MA),3 (PCC_250MA),4 (PCC_550MA),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SMBCHGL_CHGR_FCC_CFG"
      sgroup "SMBCHGL_CHGR_FCC_CFG (at 0x10f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC                                      = "
    tree.end
    tree "SMBCHGL_CHGR_FCC_CMP_CFG"
      sgroup "SMBCHGL_CHGR_FCC_CMP_CFG (at 0x10f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FCC_COMP                                 = " "0 (FCC_COMP_250MA),1 (FCC_COMP_700MA),2 (FCC_COMP_900MA),3 (FCC_COMP_1200MA)"
    tree.end
    tree "SMBCHGL_CHGR_FV_CFG"
      sgroup "SMBCHGL_CHGR_FV_CFG (at 0x10f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV                                       = "
    tree.end
    tree "SMBCHGL_CHGR_FV_CMP_CFG"
      sgroup "SMBCHGL_CHGR_FV_CMP_CFG (at 0x10f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_COMP                                  = "
    tree.end
    tree "SMBCHGL_CHGR_CFG_AFVC"
      sgroup "SMBCHGL_CHGR_CFG_AFVC (at 0x10f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHGR_AUTO_FV_COMP                        = " "0 (AUTO_FV_DISABLED),1 (AUTO_FV_25MV),2 (AUTO_FV_50MV),3 (AUTO_FV_75MV),4 (AUTO_FV_100MV),5 (AUTO_FV_125MV),6 (AUTO_FV_150MV),7 (AUTO_FV_175MV)"
    tree.end
    tree "SMBCHGL_CHGR_CFG_CHG_INHIB"
      sgroup "SMBCHGL_CHGR_CFG_CHG_INHIB (at 0x10f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHGR_INHIBIT_THRESHOLD                   = " "0 (INHIBIT_50MV),1 (INHIBIT_100MV),2 (INHIBIT_200MV),3 (INHIBIT_300MV)"
    tree.end
    tree "SMBCHGL_CHGR_CFG_P2F"
      sgroup "SMBCHGL_CHGR_CFG_P2F (at 0x10f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P2F_CHG_THRESHOLD                        = " "0 (P2F_2P4),1 (P2F_2P6),2 (P2F_2P8),3 (P2F_3P0)"
    tree.end
    tree "SMBCHGL_CHGR_CFG_TCC"
      sgroup "SMBCHGL_CHGR_CFG_TCC (at 0x10f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHG_TERM_I                               = " "0 (TERM_ANA_300MA),1 (TERM_ANA_50MA),2 (TERM_ANA_100MA),3 (TERM_ANA_150MA),4 (TERM_ANA_200MA),5 (TERM_ANA_250MA),6 (TERM_ANA_500MA),7 (TERM_ANA_600MA)"
    tree.end
    tree "SMBCHGL_CHGR_CCMP_CFG"
      sgroup "SMBCHGL_CHGR_CCMP_CFG (at 0x10fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CCMP_CFG_6                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_TEMP_HARD_LIMIT                    = " "0 (JEITA_TEMP_HARD_LIMIT_EN),1 (JEITA_TEMP_HARD_LIMIT_DIS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOAD_BAT                                 = " "0 (LOAD_BATT_FV_COMP_DIS),1 (LOAD_BATT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOT_SL_FV_COMP                           = " "0 (HOT_SOFT_LIMIT_FV_COMP_DIS),1 (HOT_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_SL_FV_COMP                          = " "0 (COLD_SOFT_LIMIT_FV_COMP_DIS),1 (COLD_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_SL_CHG_I_COMP                        = " "0 (HOT_SOFT_LIMIT_CC_COMP_DIS),1 (HOT_SOFT_LIMIT_CC_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COLD_SL_CHG_I_COMP                       = " "0 (COLD_SOFT_LIMIT_CC_COMP_DIS),1 (COLD_SOFT_LIMIT_CC_COMP_EN)"
    tree.end
    tree "SMBCHGL_CHGR_CHGR_CFG1"
      sgroup "SMBCHGL_CHGR_CHGR_CFG1 (at 0x10fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_INOK_POL                           = " "0 (SYSOK_TABLE),1 (SYSOK_TABLE_N)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SYSOK_OPTIONS                            = " "0 (INOK_OPT_1),1 (INOK_OPT_2),2 (SYSOK_OPT_A_1),3 (SYSOK_OPT_A_2),4 (SYSOK_OPT_BC_1),5 (SYSOK_OPT_BC_2),6 (CHG_DET_OPT_1),7 (CHG_DET_OPT_2)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EARLY_TERM_STATUS                        = " "0 (EARLY_CURRENT_TERM_DIS),1 (EARLY_CURRENT_TERM_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TERM_I_SRC                               = " "0 (TERM_SRC_ANA),1 (TERM_SRC_FG)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RECHG_THRESHOLD_SRC                      = " "0 (RCHG_SRC_ANA),1 (RCHG_SRC_FG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGING_HOLDOFF                         = " "0 (WAIT_FOR_FG),1 (NO_WAIT_FOR_FG)"
    tree.end
    tree "SMBCHGL_CHGR_CHGR_CFG2"
      sgroup "SMBCHGL_CHGR_CHGR_CFG2 (at 0x10fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN_SRC                               = " "0 (CHG_EN_SRC_CMD),1 (CHG_EN_SRC_PIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_COMMAND                           = " "0 (CHG_EN_POL_HIGH),1 (CHG_EN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   P2F_CHG_TRAN                             = " "0 (PRE_FAST_AUTO),1 (PRE_FAST_CMD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_ECC                               = " "0 (BATT_OV_ENDS_CYCLE_DIS),1 (BATT_OV_ENDS_CYCLE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_TERM                                   = " "0 (CURRENT_TERM_EN),1 (CURRENT_TERM_DIS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_RECHG                               = " "0 (AUTO_RCHG_EN),1 (AUTO_RCHG_DIS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOLD_OFF_TIMER_CHARGING                  = " "0 (HOLDOFF_TMR_700US),1 (HOLDOFF_TMR_350MS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGER_INHIBIT                          = " "0 (CHG_INHIBIT_DIS),1 (CHG_INHIBIT_EN)"
    tree.end
    tree "SMBCHGL_CHGR_SFT_CFG"
      sgroup "SMBCHGL_CHGR_SFT_CFG (at 0x10fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SFT_EN                                   = " "0 (PC_EN_TC_EN),1 (PC_DIS_TC_EN),2 (PC_DIS_TC_DIS),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SFT_TIMEOUT                              = " "0 (TC_TMOUT_192MIN),1 (TC_TMOUT_384MIN),2 (TC_TMOUT_768MIN),3 (TC_TMOUT_1536MIN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRE_CHG_SFT_TIMEOUT                      = " "0 (PC_TMOUT_24MIN),1 (PC_TMOUT_48MIN),2 (PC_TMOUT_96MIN),3 (PC_TMOUT_192MIN)"
    tree.end
    tree "SMBCHGL_CHGR_STAT_CFG"
      sgroup "SMBCHGL_CHGR_STAT_CFG (at 0x10fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STAT_CFG_4                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_CHG_ERROR_BLINKING_EN               = " "0 (STAT_BLINKING_DIS),1 (STAT_BLINKING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STAT_PIN_SRC                             = " "0 (STAT_CHG_STS),1 (STAT_USB_FAIL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAT_PIN_OUTPUT_POL                      = " "0 (STAT_ACTIVE_LOW),1 (STAT_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAT_PIN_OUTPUT_EN                       = " "0 (STAT_OUTPUT_EN),1 (STAT_OUTPUT_DIS)"
    tree.end
    tree "SMBCHGL_CHGR_CFG"
      sgroup "SMBCHGL_CHGR_CFG (at 0x10ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OPTION_PIN_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CFG_VCHG_IIN                             = " "0 (VCHG_BATTERY_CURRENT),1 (VCHG_INPUT_CURRENT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TAPER_DIS_AFVC                       = " "0 (AFVC_ACTIVE_IN_TAPER),1 (AFVC_DISABLE_IN_TAPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_VCHG                                 = " "0 (VCHG_DIS),1 (VCHG_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_RCHG_LVL                             = " "0 (RCHG_THRESH_100MV),1 (RCHG_THRESH_200MV)"
    tree.end
  tree.end
tree.end
tree "SMBCHGL_DC"
  tree "SMBCHGL_DC"
    tree "SMBCHGL_DC_PERPH_TYPE"
      sgroup "SMBCHGL_DC_PERPH_TYPE (at 0x1404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_DC_PERPH_SUBTYPE"
      sgroup "SMBCHGL_DC_PERPH_SUBTYPE (at 0x1405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_DC_INT_RT_STS"
      sgroup "SMBCHGL_DC_INT_RT_STS (at 0x1410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_RT_STS                           = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_SET_TYPE"
      sgroup "SMBCHGL_DC_INT_SET_TYPE (at 0x1411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_TYPE                             = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_DC_INT_POLARITY_HIGH (at 0x1412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_HIGH                             = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_POLARITY_LOW"
      sgroup "SMBCHGL_DC_INT_POLARITY_LOW (at 0x1413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LOW                              = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_LATCHED_CLR"
      sgroup "SMBCHGL_DC_INT_LATCHED_CLR (at 0x1414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_EN_SET"
      sgroup "SMBCHGL_DC_INT_EN_SET (at 0x1415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_SET                           = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_EN_CLR"
      sgroup "SMBCHGL_DC_INT_EN_CLR (at 0x1416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_CLR                           = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_LATCHED_STS"
      sgroup "SMBCHGL_DC_INT_LATCHED_STS (at 0x1418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_PENDING_STS"
      sgroup "SMBCHGL_DC_INT_PENDING_STS (at 0x1419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_PENDING_STS                      = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_MID_SEL"
      sgroup "SMBCHGL_DC_INT_MID_SEL (at 0x141a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_DC_INT_PRIORITY"
      sgroup "SMBCHGL_DC_INT_PRIORITY (at 0x141b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_SEC_ACCESS"
      sgroup "SMBCHGL_DC_SEC_ACCESS (at 0x14d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_DC_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_DC_PERPH_RESET_CTL2 (at 0x14d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_DC_PERPH_RESET_CTL3 (at 0x14da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_DC_PERPH_RESET_CTL4 (at 0x14db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_SPARE"
      sgroup "SMBCHGL_DC_SPARE (at 0x14df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_DC_INT_TEST1"
      sgroup "SMBCHGL_DC_INT_TEST1 (at 0x14e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_INT_TEST_VAL"
      sgroup "SMBCHGL_DC_INT_TEST_VAL (at 0x14e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIV2_EN_DG_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_INT_VAL                          = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_TM_EN_ATEST_DCIN"
      sgroup "SMBCHGL_DC_TM_EN_ATEST_DCIN (at 0x14e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_DCIN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_TRIM_NUM"
      sgroup "SMBCHGL_DC_TRIM_NUM (at 0x14f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_DC_DCIN_CHGR_CFG"
      sgroup "SMBCHGL_DC_DCIN_CHGR_CFG (at 0x14f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_5V_OV_SEL                           = " "0 (DCIN_5V_OV_6P3),1 (DCIN_5V_OV_7P4)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADAPTER_ALLOWANCE                        = " "0 (DCIN_ADAPTER_ALLOWANCE_5V),1 (DCIN_ADAPTER_ALLOWANCE_5V_9V),2 (DCIN_ADAPTER_ALLOWANCE_5V_TO_9V),3 (DCIN_ADAPTER_ALLOWANCE_9V)"
    tree.end
    tree "SMBCHGL_DC_DCIN_IL_CFG"
      sgroup "SMBCHGL_DC_DCIN_IL_CFG (at 0x14f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHGL_DC_DC_AICL_CFG1"
      sgroup "SMBCHGL_DC_DC_AICL_CFG1 (at 0x14f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0 (DC_OV_BLOCK),1 (DC_OV_NO_BLOCK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0 (DC_COLLAPSE_GF_NORMAL),1 (DC_COLLAPSE_GF_6P3)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0 (DC_COLLAPSE_9VGF_5MS_10MS_OR_20MS),1 (DC_COLLAPSE_9VGF_15US_10MS_OR_20MS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0 (DC_COLLAPSE_5VGF_5MS_10MS_OR_20MS),1 (DC_COLLAPSE_5VGF_15US_10MS_OR_20MS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0 (DC_AICL_DISABLED),1 (DC_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0 (DC_COLLAPSE_HV_FET_ON),1 (DC_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0 (DC_COLLAPSE_LV_FET_ON),1 (DC_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMBCHGL_DC_DC_AICL_CFG2"
      sgroup "SMBCHGL_DC_DC_AICL_CFG2 (at 0x14f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEB_UV                                   = " "0 (DC_UV_GF_20MS20MS),1 (DC_UV_GF_10US10MS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_THRESHOLD_5V_TO_9V                  = " "0 (DC_AICL_6P25_OR_4P25),1 (DC_AICL_6P75_OR_4P40)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_THRESHOLD_5V                        = " "0 (DC_AICL_5V_4P25),1 (DC_AICL_5V_4P40)"
    tree.end
    tree "SMBCHGL_DC_AICL_WL_SEL_CFG"
      sgroup "SMBCHGL_DC_AICL_WL_SEL_CFG (at 0x14f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   AICL_RESTART_TIMER                       = " "0 (AICL_RESTART_TIMER_2P8S),1 (AICL_RESTART_TIMER_5P6S),2 (AICL_RESTART_TIMER_11P3S),3 (AICL_RESTART_TIMER_22P5S),4 (AICL_RESTART_TIMER_45S),5 (AICL_RESTART_TIMER_1P5MIN),6 (AICL_RESTART_TIMER_3MIN),7 (AICL_RESTART_TIMER_6MIN)"
    tree.end
    tree "SMBCHGL_DC_TEMP_COMP_CFG"
      sgroup "SMBCHGL_DC_TEMP_COMP_CFG (at 0x14f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CFG_EN_TLOOP                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_DIS_TLOOP                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_DIS_DIG_TLOOP                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INT_TEMP_COMP_EN                         = " "0 (INT_TEMP_COMP_EN_DIS),1 (INT_TEMP_COMP_EN_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   INT_TEMP_COMP_SETTING                    = " "0 (INT_TEMP_COMP_SETTING_0),1 (INT_TEMP_COMP_SETTING_15PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_TEMP_COMP_CYCLE_TIME                 = " "0 (AINT_TEMP_COMP_CYCLE_TIME_350MS),1 (INT_TEMP_COMP_CYCLE_TIME_700MS),2 (INT_TEMP_COMP_CYCLE_TIME_31P4S),3 (INT_TEMP_COMP_CYCLE_TIME_2P8S)"
    tree.end
    tree "SMBCHGL_DC_TRIM7"
      sgroup "SMBCHGL_DC_TRIM7 (at 0x14f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_80R32B                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_LORAMP                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_LONG_REFRESH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_GAIN1X                                = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_TRIM8"
      sgroup "SMBCHGL_DC_TRIM8 (at 0x14f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_SCTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TR_OSC3M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_OSC2M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_DC_TRIM9"
      sgroup "SMBCHGL_DC_TRIM9 (at 0x14f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_DUTY                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TR_ZDTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_BLTR                                  = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_DC_TR_TEMP"
      sgroup "SMBCHGL_DC_TR_TEMP (at 0x14fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_TEMP                                  = "
    tree.end
    tree "SMBCHGL_DC_TRIM11"
      sgroup "SMBCHGL_DC_TRIM11 (at 0x14fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TR_HICAP_VMODE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_SOFT                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_BT                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_DIS_SSUD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_NEW_TRIM                              = " "0, 1"
    tree.end
    tree "SMBCHGL_DC_TRIM12"
      sgroup "SMBCHGL_DC_TRIM12 (at 0x14fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_VD                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_VDTHRES                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_DC_TR_DCIN_SNS"
      sgroup "SMBCHGL_DC_TR_DCIN_SNS (at 0x14fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TEST_AMP                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TR_DCIN_SNS_5                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CLKCFG_SEL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BUCK_ISNS_SEL                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLKSEL                                   = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_DC_TR_DCIN_DIVIDER"
      sgroup "SMBCHGL_DC_TR_DCIN_DIVIDER (at 0x14fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DCIN_DIVIDER                          = "
    tree.end
    tree "SMBCHGL_DC_TR_IINOS_DC"
      sgroup "SMBCHGL_DC_TR_IINOS_DC (at 0x14ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_DC                              = "
    tree.end
  tree.end
tree.end
tree "SMBCHGL_MISC"
  tree "SMBCHGL_MISC"
    tree "SMBCHGL_MISC_REVISION1"
      sgroup "SMBCHGL_MISC_REVISION1 (at 0x1600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMBCHGL_MISC_REVISION2"
      sgroup "SMBCHGL_MISC_REVISION2 (at 0x1601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMBCHGL_MISC_REVISION3"
      sgroup "SMBCHGL_MISC_REVISION3 (at 0x1602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SMBCHGL_MISC_REVISION4"
      sgroup "SMBCHGL_MISC_REVISION4 (at 0x1603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SMBCHGL_MISC_PERPH_TYPE"
      sgroup "SMBCHGL_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_MISC_PERPH_SUBTYPE"
      sgroup "SMBCHGL_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_MISC_IDEV_STS"
      sgroup "SMBCHGL_MISC_IDEV_STS (at 0x1608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SRC_DETECT_STS                           = "
    tree.end
    tree "SMBCHGL_MISC_INT_RT_STS"
      sgroup "SMBCHGL_MISC_INT_RT_STS (at 0x1610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_SET_TYPE"
      sgroup "SMBCHGL_MISC_INT_SET_TYPE (at 0x1611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_MISC_INT_POLARITY_HIGH (at 0x1612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_POLARITY_LOW"
      sgroup "SMBCHGL_MISC_INT_POLARITY_LOW (at 0x1613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_LATCHED_CLR"
      sgroup "SMBCHGL_MISC_INT_LATCHED_CLR (at 0x1614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_EN_SET"
      sgroup "SMBCHGL_MISC_INT_EN_SET (at 0x1615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_EN_CLR"
      sgroup "SMBCHGL_MISC_INT_EN_CLR (at 0x1616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_LATCHED_STS"
      sgroup "SMBCHGL_MISC_INT_LATCHED_STS (at 0x1618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_PENDING_STS"
      sgroup "SMBCHGL_MISC_INT_PENDING_STS (at 0x1619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_MID_SEL"
      sgroup "SMBCHGL_MISC_INT_MID_SEL (at 0x161a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_MISC_INT_PRIORITY"
      sgroup "SMBCHGL_MISC_INT_PRIORITY (at 0x161b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_WDOG_RST"
      sgroup "SMBCHGL_MISC_WDOG_RST (at 0x1640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_RST                                 = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_AFP_MODE"
      sgroup "SMBCHGL_MISC_AFP_MODE (at 0x1641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_MODE_ENB                             = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_GSM_PA_ON_ADJ_EN"
      sgroup "SMBCHGL_MISC_GSM_PA_ON_ADJ_EN (at 0x1642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GSM_PA_ON_ADJ_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_SEC_ACCESS"
      sgroup "SMBCHGL_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_MISC_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_SPARE"
      sgroup "SMBCHGL_MISC_SPARE (at 0x16df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_MISC_INT_TEST1"
      sgroup "SMBCHGL_MISC_INT_TEST1 (at 0x16e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_INT_TEST_VAL"
      sgroup "SMBCHGL_MISC_INT_TEST_VAL (at 0x16e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_INT_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_TEST_MODE"
      sgroup "SMBCHGL_MISC_TEST_MODE (at 0x16e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TM_IPWR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_CPATH_OS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_OTG_EN_HS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   TM_BB_LOOPS                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_DIS_SYSOV                             = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_TEST_EN"
      sgroup "SMBCHGL_MISC_TEST_EN (at 0x16e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TE_IIN_FB                                = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_79_72"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_79_72 (at 0x16e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_79_72                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_71_64"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_71_64 (at 0x16e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_71_64                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_63_56"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_63_56 (at 0x16e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_63_56                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_55_48"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_55_48 (at 0x16e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_55_48                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_47_40"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_47_40 (at 0x16e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_47_40                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_39_32"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_39_32 (at 0x16e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_39_32                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_31_24"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_31_24 (at 0x16ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_31_24                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_23_16"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_23_16 (at 0x16eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_23_16                 = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_15_8"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_15_8 (at 0x16ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_15_8                  = "
    tree.end
    tree "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_7_0"
      sgroup "SMBCHGL_MISC_TEST_OUTPUT_MUX_IN_7_0 (at 0x16ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_7_0                   = "
    tree.end
    tree "SMBCHGL_MISC_HVDCP_TST"
      sgroup "SMBCHGL_MISC_HVDCP_TST (at 0x16ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HVDCP_TST                                = "
    tree.end
    tree "SMBCHGL_MISC_TEST_MODE_STDBYOSC"
      sgroup "SMBCHGL_MISC_TEST_MODE_STDBYOSC (at 0x16ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TEST_MODE_STDBYOSC                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_MISC_TRIM_NUM"
      sgroup "SMBCHGL_MISC_TRIM_NUM (at 0x16f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_MISC_WD_CFG"
      sgroup "SMBCHGL_MISC_WD_CFG (at 0x16f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_WDOG_ENABLE                          = " "0 (AFP_WDOG_DIS),1 (AFP_WDOG_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   WDOG_TIMEOUT                             = " "0 (WDOG_TMOUT_18S),1 (WDOG_TMOUT_36S),2 (WDOG_TMOUT_72S),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SFT_AFTER_WDOG_IRQ                       = " "0 (TIMER_AFTER_WDOG_12MIN),1 (TIMER_AFTER_WDOG_24MIN),2 (TIMER_AFTER_WDOG_48MIN),3 (TIMER_AFTER_WDOG_96MIN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_IRQ_SFT                             = " "0 (WDOG_IRQ_TIMER_DIS),1 (WDOG_IRQ_TIMER_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_OPTION                              = " "0 (WDOG_AFTER_ACK),1 (WDOG_ALWAYS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_TIMER_EN                            = " "0 (WDOG_DIS),1 (WDOG_EN)"
    tree.end
    tree "SMBCHGL_MISC_MISC_CFG"
      sgroup "SMBCHGL_MISC_MISC_CFG (at 0x16f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MISC_CFG_7                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WIPWR_UVLO_IRQ_OPT                       = " "0 (CHG_OK_DEPENDENT),1 (CHG_OK_INDEPENDENT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_NTCVOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PMUX_OTG_DLY_EN                          = " "0 (NO_OTG_USB_EN_DELAY),1 (OTG_USB_EN_DELAY_1MS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHG_OK                                   = " "0 (CHG_OK_DIS),1 (CHG_OK_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MISC_CFG_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GSM_PA_ON_ADJ_SEL                        = " "0 (PA_ON_DIS),1 (PA_ON_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MISC_CFG_0                               = " "0, 1"
    tree.end
    tree "SMBCHGL_MISC_CFG_NTC_VOUT"
      sgroup "SMBCHGL_MISC_CFG_NTC_VOUT (at 0x16f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CFG_NTC_VOUT                             = "
    tree.end
    tree "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_16"
      sgroup "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_16 (at 0x16f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   PMI8994_CHARGER_OPTIONS                  = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_STOP_TBIT                           = " "0 (SOFT_STOP_DIS),1 (SOFT_STOP_EN)"
    tree.end
    tree "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_15_8"
      sgroup "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_15_8 (at 0x16f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_INIT                                = " "0 (AICL_INITIAL_0),1 (AICL_INITIAL_ICL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_ADC                                 = " "0 (AICL_ADC_DIS),1 (AICL_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_RERUN_AICL                         = " "0 (AICL_USB_RERUN_DIS),1 (AICL_USB_RERUN_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_RERUN_AICL                          = " "0 (AICL_DC_RERUN_DIS),1 (AICL_DC_RERUN_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_DCIN_SEL                           = " "0 (SYSOK_OPT_B),1 (SYSOK_OPT_C)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PRE_BYPASS_GF_TBIT                       = " "0 (BYPASS_GF_DIS),1 (BYPASS_GF_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STANDBY_OSC_EN                           = " "0 (STDBY_OSC_OVERRIDE_DIS),1 (STDBY_OSC_OVERRIDE_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAIN_OSC_EN                              = " "0 (MAIN_OSC_OVERRIDE_DIS),1 (MAIN_OSC_OVERRIDE_EN)"
    tree.end
    tree "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_7_0"
      sgroup "SMBCHGL_MISC_CHGR_TRIM_OPTIONS_7_0 (at 0x16f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ESR_DURING_TAPER                         = " "0 (TAPER_ESR_EN),1 (TAPER_ESR_DIS)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TLIM_DIS_TBIT                            = " "0 (TLIM_EN),1 (TLIM_DIS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OV_OPTION_TBIT                           = " "0 (OV_OPT_MID_LOAD),1 (OV_OPT_NO_MID_LOAD),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TBIT_IMP_EN                              = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OPT_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ARB_FIX_TBIT                         = " "0 (RAISE_ARB_THRESHOLD),1 (ARB_THRESHOLD_SEL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DB_TMR_DIS_TBIT                          = " "0 (DEAD_BATT_TIMER_EN),1 (DEAD_BATT_TIMER_DIS)"
    tree.end
    tree "SMBCHGL_MISC_TR_IPWR1"
      sgroup "SMBCHGL_MISC_TR_IPWR1 (at 0x16f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR1                                 = "
    tree.end
    tree "SMBCHGL_MISC_TR_IPWR2"
      sgroup "SMBCHGL_MISC_TR_IPWR2 (at 0x16f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR2                                 = "
    tree.end
    tree "SMBCHGL_MISC_TRIM9"
      sgroup "SMBCHGL_MISC_TRIM9 (at 0x16f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_VCHG_IOUT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_VCHG_IIN                              = "
    tree.end
    tree "SMBCHGL_MISC_TRIM10"
      sgroup "SMBCHGL_MISC_TRIM10 (at 0x16fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_TERM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_BATLOW                                = "
    tree.end
    tree "SMBCHGL_MISC_TRIM11"
      sgroup "SMBCHGL_MISC_TRIM11 (at 0x16fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_RT                                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TR_1356                                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCALE_FULLON                          = "
    tree.end
    tree "SMBCHGL_MISC_TRIM12"
      sgroup "SMBCHGL_MISC_TRIM12 (at 0x16fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTOS                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTCS_CHGOS                          = "
    tree.end
    tree "SMBCHGL_MISC_TRIM13"
      sgroup "SMBCHGL_MISC_TRIM13 (at 0x16fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTCS_OTGOS                          = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTOS_PRECHG                         = "
    tree.end
    tree "SMBCHGL_MISC_TRIM14"
      sgroup "SMBCHGL_MISC_TRIM14 (at 0x16fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_FLT_SCALE                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_FLT_OFFSET                            = "
    tree.end
    tree "SMBCHGL_MISC_CFG_TEMP_SEL"
      sgroup "SMBCHGL_MISC_CFG_TEMP_SEL (at 0x16ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_TEMP_SEL                             = " "0 (TEMP_LOOP_100DEG),1 (TEMP_LOOP_110DEG),2 (TEMP_LOOP_120DEG),3 (TEMP_LOOP_130DEG)"
    tree.end
  tree.end
tree.end
tree "SMBCHGL_OTG"
  tree "SMBCHGL_OTG"
    tree "SMBCHGL_OTG_PERPH_TYPE"
      sgroup "SMBCHGL_OTG_PERPH_TYPE (at 0x1104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_OTG_PERPH_SUBTYPE"
      sgroup "SMBCHGL_OTG_PERPH_SUBTYPE (at 0x1105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_OTG_INT_RT_STS"
      sgroup "SMBCHGL_OTG_INT_RT_STS (at 0x1110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_SET_TYPE"
      sgroup "SMBCHGL_OTG_INT_SET_TYPE (at 0x1111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_TYPE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_OTG_INT_POLARITY_HIGH (at 0x1112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_HIGH                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_POLARITY_LOW"
      sgroup "SMBCHGL_OTG_INT_POLARITY_LOW (at 0x1113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_LOW                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_LATCHED_CLR"
      sgroup "SMBCHGL_OTG_INT_LATCHED_CLR (at 0x1114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_EN_SET"
      sgroup "SMBCHGL_OTG_INT_EN_SET (at 0x1115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_EN_SET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_EN_CLR"
      sgroup "SMBCHGL_OTG_INT_EN_CLR (at 0x1116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_EN_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_LATCHED_STS"
      sgroup "SMBCHGL_OTG_INT_LATCHED_STS (at 0x1118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_LATCHED_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_PENDING_STS"
      sgroup "SMBCHGL_OTG_INT_PENDING_STS (at 0x1119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_PENDING_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_MID_SEL"
      sgroup "SMBCHGL_OTG_INT_MID_SEL (at 0x111a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_OTG_INT_PRIORITY"
      sgroup "SMBCHGL_OTG_INT_PRIORITY (at 0x111b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_SEC_ACCESS"
      sgroup "SMBCHGL_OTG_SEC_ACCESS (at 0x11d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_OTG_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_OTG_PERPH_RESET_CTL2 (at 0x11d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_OTG_PERPH_RESET_CTL3 (at 0x11da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_OTG_PERPH_RESET_CTL4 (at 0x11db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_TEST1"
      sgroup "SMBCHGL_OTG_INT_TEST1 (at 0x11dd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011dd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11dd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_INT_TEST_VAL"
      sgroup "SMBCHGL_OTG_INT_TEST_VAL (at 0x11de)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011de0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11de0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OC_DIS_SW_INT_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RID_CHANGE_DET_INT_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_GND_DET_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_SPARE"
      sgroup "SMBCHGL_OTG_SPARE (at 0x11df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_OTG_TEST_EN_CFG"
      sgroup "SMBCHGL_OTG_TEST_EN_CFG (at 0x11e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TESTMODE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_INPUT_MUX_ENABLE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_OUTPUT_MUX_ENABLE                   = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_TEST_55_48"
      sgroup "SMBCHGL_OTG_TEST_55_48 (at 0x11e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_55_48                               = "
    tree.end
    tree "SMBCHGL_OTG_TEST_47_40"
      sgroup "SMBCHGL_OTG_TEST_47_40 (at 0x11e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_47_40                               = "
    tree.end
    tree "SMBCHGL_OTG_TEST_41_32"
      sgroup "SMBCHGL_OTG_TEST_41_32 (at 0x11e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_41_32                               = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_95_88"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_95_88 (at 0x11e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_95_88                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_87_80"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_87_80 (at 0x11e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_87_80                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_79_72"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_79_72 (at 0x11e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_79_72                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_71_64"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_71_64 (at 0x11e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_71_64                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_63_56"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_63_56 (at 0x11e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_63_56                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_55_48"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_55_48 (at 0x11e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_55_48                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_47_40"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_47_40 (at 0x11ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_47_40                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_39_32"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_39_32 (at 0x11eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_39_32                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_31_24"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_31_24 (at 0x11ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_31_24                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_23_16"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_23_16 (at 0x11ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_23_16                  = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_15_8"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_15_8 (at 0x11ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_15_8                   = "
    tree.end
    tree "SMBCHGL_OTG_TEST_INPUT_MUX_IN_7_0"
      sgroup "SMBCHGL_OTG_TEST_INPUT_MUX_IN_7_0 (at 0x11ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_7_0                    = "
    tree.end
    tree "SMBCHGL_OTG_TRIM_NUM"
      sgroup "SMBCHGL_OTG_TRIM_NUM (at 0x11f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_OTG_OTG_CFG"
      sgroup "SMBCHGL_OTG_OTG_CFG (at 0x11f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OTG_OC_FLG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTG_OC_CFG                               = " "0 (HICCUP_DISABLED),1 (HICCUP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HV_OTG_PROTECTION                        = " "0 (HV_OTG_DISABLED),1 (HV_OTG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_PIN_POL                              = " "0 (OTG_PIN_POL_HIGH),1 (OTG_PIN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OTG_CTRL                                 = " "0 (reserved),1 (reserved),2 (OTG_CTRL_CMD),3 (OTG_CTRL_AUTO)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_UVLO_SENSOR_SRC                      = " "0 (OTG_UVLO_SENSOR_ANA),1 (reserved),2 (OTG_UVLO_SENSOR_FG),3 (OTG_UVLO_SENSOR_OR)"
    tree.end
    tree "SMBCHGL_OTG_CFG_BATTUV"
      sgroup "SMBCHGL_OTG_CFG_BATTUV (at 0x11f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BATTUV                               = " "0 (OTG_BATTUV_2P7),1 (OTG_BATTUV_2P9),2 (OTG_BATTUV_3P1),3 (OTG_BATTUV_3P3)"
    tree.end
    tree "SMBCHGL_OTG_OTG_ICFG"
      sgroup "SMBCHGL_OTG_OTG_ICFG (at 0x11f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_ILIMIT                               = " "0 (OTG_ILIMIT_250MA),1 (OTG_ILIMIT_600MA),2 (OTG_ILIMIT_750MA),3 (OTG_ILIMIT_1000MA)"
    tree.end
    tree "SMBCHGL_OTG_TR_ISOTG"
      sgroup "SMBCHGL_OTG_TR_ISOTG (at 0x11f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_ISOTG                                 = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_OTG_TR_OTG_SNS"
      sgroup "SMBCHGL_OTG_TR_OTG_SNS (at 0x11f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_OTG_SNS                               = "
    tree.end
    tree "SMBCHGL_OTG_TRIM6"
      sgroup "SMBCHGL_OTG_TRIM6 (at 0x11f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_ENB_ZD                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_ENB_SKIP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_EN_FPWM_USB1                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_ENLS_SS                               = " "0, 1"
    tree.end
    tree "SMBCHGL_OTG_TR_ISTR"
      sgroup "SMBCHGL_OTG_TR_ISTR (at 0x11f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISTR                                  = "
    tree.end
    tree "SMBCHGL_OTG_CFG_TLOOP"
      sgroup "SMBCHGL_OTG_CFG_TLOOP (at 0x11f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   TR_SCALE_LINEAR                          = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_TLOOP                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_OTG_CHG_PBS_TRIG_CONTROL"
      sgroup "SMBCHGL_OTG_CHG_PBS_TRIG_CONTROL (at 0x11f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_PBS_TRIG_CONTROL                     = "
    tree.end
    tree "SMBCHGL_OTG_TR_PWR_TR"
      sgroup "SMBCHGL_OTG_TR_PWR_TR (at 0x11fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR                                = "
    tree.end
    tree "SMBCHGL_OTG_TR_PWR_TRB_A"
      sgroup "SMBCHGL_OTG_TR_PWR_TRB_A (at 0x11fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_A                             = "
    tree.end
    tree "SMBCHGL_OTG_TR_PWR_TRB_B"
      sgroup "SMBCHGL_OTG_TR_PWR_TRB_B (at 0x11fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_B                             = "
    tree.end
    tree "SMBCHGL_OTG_TR_PWR_TRS"
      sgroup "SMBCHGL_OTG_TR_PWR_TRS (at 0x11fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRS                               = "
    tree.end
    tree "SMBCHGL_OTG_TR_PWR_TR_BGTR"
      sgroup "SMBCHGL_OTG_TR_PWR_TR_BGTR (at 0x11fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR_BGTR                           = "
    tree.end
    tree "SMBCHGL_OTG_LOW_PWR_OPTIONS"
      sgroup "SMBCHGL_OTG_LOW_PWR_OPTIONS (at 0x11ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_PWR_OPTIONS                          = "
    tree.end
  tree.end
tree.end
tree "SMBCHGL_USB"
  tree "SMBCHGL_USB"
    tree "SMBCHGL_USB_PERPH_TYPE"
      sgroup "SMBCHGL_USB_PERPH_TYPE (at 0x1304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_USB_PERPH_SUBTYPE"
      sgroup "SMBCHGL_USB_PERPH_SUBTYPE (at 0x1305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_USB_ICL_STS_1"
      sgroup "SMBCHGL_USB_ICL_STS_1 (at 0x1307)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OTST1                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICL_MIN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ICL_STS                                  = "
    tree.end
    tree "SMBCHGL_USB_PWR_PTH_STS"
      sgroup "SMBCHGL_USB_PWR_PTH_STS (at 0x1308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   POWER_PATH                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_USB_ICL_STS_2"
      sgroup "SMBCHGL_USB_ICL_STS_2 (at 0x1309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_ILIMIT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HIGH_DUTY_CYCLE_PULSE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ICL_MODE                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_SUSPEND_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_SUSPEND_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_ACTIVE_PWR_SRC                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_ACTIVE_PWR_SRC                      = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_APSD_DG_STS"
      sgroup "SMBCHGL_USB_APSD_DG_STS (at 0x130a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCD_TIMEOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RID_ABC_DG                               = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_RID_STS"
      sgroup "SMBCHGL_USB_RID_STS (at 0x130b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RID_STS                                  = "
    tree.end
    tree "SMBCHGL_USB_HVDCP_STS"
      sgroup "SMBCHGL_USB_HVDCP_STS (at 0x130c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HVDCP_2P1_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_TRIGGER                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   COMMAND_DEC                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   COMMAND_INC                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_SEL_IDLE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HVDCP_SEL_9V                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HVDCP_SEL_5V                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IDEV_HVDCP_SEL_A                         = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INPUT_STS"
      sgroup "SMBCHGL_USB_INPUT_STS (at 0x130d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   USBIN_INPUT_STS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DCIN_INPUT_STS                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_USB_USBID_VALID_ID_11_8"
      sgroup "SMBCHGL_USB_USBID_VALID_ID_11_8 (at 0x130e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USBID_VALID_ID_11_8                      = "
    tree.end
    tree "SMBCHGL_USB_USBID_VALID_ID_7_0"
      sgroup "SMBCHGL_USB_USBID_VALID_ID_7_0 (at 0x130f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USBID_VALID_ID_7_0                       = "
    tree.end
    tree "SMBCHGL_USB_INT_RT_STS"
      sgroup "SMBCHGL_USB_INT_RT_STS (at 0x1310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_SET_TYPE"
      sgroup "SMBCHGL_USB_INT_SET_TYPE (at 0x1311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_USB_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_POLARITY_LOW"
      sgroup "SMBCHGL_USB_INT_POLARITY_LOW (at 0x1313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_LATCHED_CLR"
      sgroup "SMBCHGL_USB_INT_LATCHED_CLR (at 0x1314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_EN_SET"
      sgroup "SMBCHGL_USB_INT_EN_SET (at 0x1315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_EN_CLR"
      sgroup "SMBCHGL_USB_INT_EN_CLR (at 0x1316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_LATCHED_STS"
      sgroup "SMBCHGL_USB_INT_LATCHED_STS (at 0x1318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_PENDING_STS"
      sgroup "SMBCHGL_USB_INT_PENDING_STS (at 0x1319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_MID_SEL"
      sgroup "SMBCHGL_USB_INT_MID_SEL (at 0x131a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_USB_INT_PRIORITY"
      sgroup "SMBCHGL_USB_INT_PRIORITY (at 0x131b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_CMD_IL"
      sgroup "SMBCHGL_USB_CMD_IL (at 0x1340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SHDN_N_CLEAR_CMD                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_2_SYS_FET_DIS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_SUSPEND                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_SUSPEND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICL_OVERRIDE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51_MODE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_MODE_CHG                           = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_CMD_APSD"
      sgroup "SMBCHGL_USB_CMD_APSD (at 0x1341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_RERUN                               = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_CMD_HVDCP_1"
      sgroup "SMBCHGL_USB_CMD_HVDCP_1 (at 0x1342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_HVDCP_2P0                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_INCREMENT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CONTINUOUS_DECREMENT                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS_INCREMENT                     = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_CMD_HVDCP_2"
      sgroup "SMBCHGL_USB_CMD_HVDCP_2 (at 0x1343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SINGLE_DECREMENT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SINGLE_INCREMENT                         = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_SEC_ACCESS"
      sgroup "SMBCHGL_USB_SEC_ACCESS (at 0x13d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_USB_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_USB_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_USB_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_USB_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_SPARE"
      sgroup "SMBCHGL_USB_SPARE (at 0x13df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_USB_INT_TEST1"
      sgroup "SMBCHGL_USB_INT_TEST1 (at 0x13e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_INT_TEST_VAL"
      sgroup "SMBCHGL_USB_INT_TEST_VAL (at 0x13e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IRQ_SPARE_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_AUTHENTICATION_DONE_INT_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_TM_EN_ATEST_USBIN"
      sgroup "SMBCHGL_USB_TM_EN_ATEST_USBIN (at 0x13e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_USBIN                        = " "0, 1"
    tree.end
    tree "SMBCHGL_USB_TEST_63_56"
      sgroup "SMBCHGL_USB_TEST_63_56 (at 0x13e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_63_56                               = "
    tree.end
    tree "SMBCHGL_USB_TEST_23_16"
      sgroup "SMBCHGL_USB_TEST_23_16 (at 0x13e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_23_16                               = "
    tree.end
    tree "SMBCHGL_USB_TEST_31_24"
      sgroup "SMBCHGL_USB_TEST_31_24 (at 0x13e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_31_24                               = "
    tree.end
    tree "SMBCHGL_USB_TRIM_NUM"
      sgroup "SMBCHGL_USB_TRIM_NUM (at 0x13f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_USB_USBIN_CHGR_CFG"
      sgroup "SMBCHGL_USB_USBIN_CHGR_CFG (at 0x13f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_5V_OV_SEL                          = " "0 (USBIN_5V_OV_6P3),1 (USBIN_5V_OV_7P4)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADAPTER_ALLOWANCE                        = " "0 (USBIN_ADAPTER_ALLOWANCE_5V),1 (USBIN_ADAPTER_ALLOWANCE_5V_9V),2 (USBIN_ADAPTER_ALLOWANCE_5V_TO_9V),3 (USBIN_ADAPTER_ALLOWANCE_9V)"
    tree.end
    tree "SMBCHGL_USB_USBIN_IL_CFG"
      sgroup "SMBCHGL_USB_USBIN_IL_CFG (at 0x13f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHGL_USB_USB_AICL_CFG"
      sgroup "SMBCHGL_USB_USB_AICL_CFG (at 0x13f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0 (USB_OV_BLOCK),1 (USB_OV_NO_BLOCK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0 (USB_COLLAPSE_GF_NORMAL),1 (USB_COLLAPSE_GF_6P3)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0 (USB_COLLAPSE_9VGF_5MS20MS),1 (USB_COLLAPSE_9VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0 (USB_COLLAPSE_5VGF_5MS20MS),1 (USB_COLLAPSE_5VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0 (USB_AICL_DISABLED),1 (USB_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0 (USB_COLLAPSE_HV_FET_ON),1 (USB_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0 (USB_COLLAPSE_LV_FET_ON),1 (USB_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMBCHGL_USB_CFG"
      sgroup "SMBCHGL_USB_CFG (at 0x13f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CFG_USB3P0_SEL                           = " "0 (USB_2P0_SEL),1 (USB_3P0_SEL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_SUSPEND_SRC                        = " "0 (BATID_UNKNOWN_CHARGE),1 (BATID_UNKNOWN_NO_CHARGE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HVDCP_ADAPTER_SEL                        = " "0 (HVDCP_5V),1 (HVDCP_9V),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_EN                                 = " "0 (HVDCP_DISABLE),1 (HVDCP_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB51_COMMAND_POL                        = " "0 (USB51AC_COMMAND1_500),1 (USB51AC_COMMAND1_100)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51AC_CTRL                             = " "0 (USB51_COMMAND_CONTROL),1 (USB51_PIN_CONTROL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB51AC_PIN_CTRL                         = " "0 (USB51AC_TRISTATE),1 (USB51AC_DUALSTATE)"
    tree.end
    tree "SMBCHGL_USB_APSD_CFG"
      sgroup "SMBCHGL_USB_APSD_CFG (at 0x13f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_PRIORITY                           = " "0 (DCIN_PRIORITY),1 (USBIN_PRIORITY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_FAIL_OPTION                          = " "0 (USB_FAIL_NORMAL),1 (USB_FAIL_POK_HV)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCD_ISEL                                 = " "0 (OCD_ISEL_500),1 (OCD_ISEL_HC)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SDP_SUSPEND                              = " "0 (SDP_NORMAL),1 (SDP_SUSPEND)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBATT_LOW_SDP                            = " "0 (VBATT_SDP_NORMAL),1 (VBATT_SDP_500MA)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RID_CLK_SEL                              = " "0 (RID_1KHZ),1 (RID_2KHZ)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCD_OPTION                               = " "0 (DCD_DG_TMOUT),1 (DCD_TMOUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTO_SRC_DETECT                          = " "0 (AUTO_SRC_DETECT_DIS),1 (AUTO_SRC_DETECT_EN)"
    tree.end
    tree "SMBCHGL_USB_TRIM6"
      sgroup "SMBCHGL_USB_TRIM6 (at 0x13f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TR_8OR32B                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TR_SYSON_ILIM                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SYSON_LDO                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_USB_TR_USB100_SNS"
      sgroup "SMBCHGL_USB_TR_USB100_SNS (at 0x13f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB100_SNS                            = "
    tree.end
    tree "SMBCHGL_USB_TR_USB500_SNS"
      sgroup "SMBCHGL_USB_TR_USB500_SNS (at 0x13f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB500_SNS                            = "
    tree.end
    tree "SMBCHGL_USB_TRIM9"
      sgroup "SMBCHGL_USB_TRIM9 (at 0x13f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IINOS_USBL                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_USB                             = "
    tree.end
    tree "SMBCHGL_USB_TR_RID"
      sgroup "SMBCHGL_USB_TR_RID (at 0x13fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HVDCP_AUTH_ALG_EN_CFG                    = " "0 (HVDCP_AUTH_DIS),1 (HVDCP_AUTH_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HVDCP_AUTO_CFG                           = " "0 (AUTO_INC_COMMAND),1 (AUTO_INC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RID_ALG                                  = " "0 (RID_FG),1 (RID_SMB)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INPUT_FET_WAIT_FOR_FG                    = " "0 (FET_DELAY),1 (FET_NO_DELAY)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_RID                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_USB_TRIM11"
      sgroup "SMBCHGL_USB_TRIM11 (at 0x13fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SYSON_CFG                                = " "0 (SYSON_OTG_BATT),1 (SYSON_OTG_BATT_USBMID),2 (SYSON_OTG_USBMID),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TR_DPDM_PUP                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DPLUS                                 = "
    tree.end
    tree "SMBCHGL_USB_NEAL6"
      sgroup "SMBCHGL_USB_NEAL6 (at 0x13fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCHGP_OPTION4                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCHGP_OPTION3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCHGP_OPTION2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCHGP_OPTION1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_LP_OSC_OPTION_BIT                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_IIN_OPT                               = " "0 (EN_IIN_BUF_SS_DONE),1 (EN_IIN_BUF_SYSON_LDO)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OC_OPT                                   = " "0 (VSYS_SHORT_DIS),1 (VSYS_SHORT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYSON_OPT                                = " "0 (SYSON_LDO_DEFAULT),1 (SYSON_LDO_INPUT_FET_ON)"
    tree.end
    tree "SMBCHGL_USB_TR_USBIN_DIVIDER"
      sgroup "SMBCHGL_USB_TR_USBIN_DIVIDER (at 0x13fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCHGP_OPTION8                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCHGP_OPTION7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCHGP_OPTION6                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCHGP_OPTION5                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_USBIN_DIVIDER                         = "
    tree.end
    tree "SMBCHGL_USB_TR_8OR32B"
      sgroup "SMBCHGL_USB_TR_8OR32B (at 0x13fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_ISENSE_LOW_CURR                       = "
    tree.end
    tree "SMBCHGL_USB_WI_PWR_OPTIONS"
      sgroup "SMBCHGL_USB_WI_PWR_OPTIONS (at 0x13ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BUCK_HOLDOFF_ENABLE                      = " "0 (WIPWR_BUCK_HOLDOFF_DIS),1 (WIPWR_BUCK_HOLDOFF_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHG_OK_HW_SW_SELECT                      = " "0 (CHG_OK_SW),1 (CHG_OK_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_RST_ENABLE                         = " "0 (WIPWR_RST_DIS),1 (WIPWR_RST_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_WIPWR_IRQ_SELECT                    = " "0 (DCIN_IRQ_SEL),1 (WIPWR_IRQ_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_SWITCH_ENABLE                       = " "0 (WIPWR_AICL_SWITCH_DIS),1 (WIPWR_AICL_SWITCH_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZIN_ICL_ENABLE                           = " "0 (ICL_CHARGER_REGS),1 (ICL_WIPWR_REGS)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "VADC1_USR"
  tree "VADC1_USR"
    tree "VADC1_USR_REVISION1"
      sgroup "VADC1_USR_REVISION1 (at 0x3100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION2"
      sgroup "VADC1_USR_REVISION2 (at 0x3101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_USR_REVISION3"
      sgroup "VADC1_USR_REVISION3 (at 0x3102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION4"
      sgroup "VADC1_USR_REVISION4 (at 0x3103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_USR_PERPH_TYPE"
      sgroup "VADC1_USR_PERPH_TYPE (at 0x3104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_USR_PERPH_SUBTYPE"
      sgroup "VADC1_USR_PERPH_SUBTYPE (at 0x3105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_USR_STATUS1"
      sgroup "VADC1_USR_STATUS1 (at 0x3108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_USR_STATUS2"
      sgroup "VADC1_USR_STATUS2 (at 0x3109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_RT_STS"
      sgroup "VADC1_USR_INT_RT_STS (at 0x3110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_SET_TYPE"
      sgroup "VADC1_USR_INT_SET_TYPE (at 0x3111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_HIGH"
      sgroup "VADC1_USR_INT_POLARITY_HIGH (at 0x3112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_LOW"
      sgroup "VADC1_USR_INT_POLARITY_LOW (at 0x3113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_CLR"
      sgroup "VADC1_USR_INT_LATCHED_CLR (at 0x3114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_USR_INT_EN_SET"
      sgroup "VADC1_USR_INT_EN_SET (at 0x3115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_EN_CLR"
      sgroup "VADC1_USR_INT_EN_CLR (at 0x3116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_STS"
      sgroup "VADC1_USR_INT_LATCHED_STS (at 0x3118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_USR_INT_PENDING_STS"
      sgroup "VADC1_USR_INT_PENDING_STS (at 0x3119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_USR_INT_MID_SEL"
      sgroup "VADC1_USR_INT_MID_SEL (at 0x311a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_USR_INT_PRIORITY"
      sgroup "VADC1_USR_INT_PRIORITY (at 0x311b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_USR_MODE_CTL"
      sgroup "VADC1_USR_MODE_CTL (at 0x3140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_USR_EN_CTL1"
      sgroup "VADC1_USR_EN_CTL1 (at 0x3146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_USR_ADC_CH_SEL_CTL"
      sgroup "VADC1_USR_ADC_CH_SEL_CTL (at 0x3148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_USR_ADC_DIG_PARAM"
      sgroup "VADC1_USR_ADC_DIG_PARAM (at 0x3150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_USR_HW_SETTLE_DELAY"
      sgroup "VADC1_USR_HW_SETTLE_DELAY (at 0x3151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_USR_CONV_REQ"
      sgroup "VADC1_USR_CONV_REQ (at 0x3152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_USR_CONV_SEQ_CTL"
      sgroup "VADC1_USR_CONV_SEQ_CTL (at 0x3154)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_USR_CONV_SEQ_TRIG_CTL"
      sgroup "VADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_CTL"
      sgroup "VADC1_USR_MEAS_INTERVAL_CTL (at 0x3157)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_USR_FAST_AVG_CTL"
      sgroup "VADC1_USR_FAST_AVG_CTL (at 0x315a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_USR_FAST_AVG_EN"
      sgroup "VADC1_USR_FAST_AVG_EN (at 0x315b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_USR_LOW_THR0"
      sgroup "VADC1_USR_LOW_THR0 (at 0x315c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_USR_LOW_THR1"
      sgroup "VADC1_USR_LOW_THR1 (at 0x315d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR0"
      sgroup "VADC1_USR_HIGH_THR0 (at 0x315e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR1"
      sgroup "VADC1_USR_HIGH_THR1 (at 0x315f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_USR_DATA0"
      sgroup "VADC1_USR_DATA0 (at 0x3160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_USR_DATA1"
      sgroup "VADC1_USR_DATA1 (at 0x3161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR0"
      sgroup "VADC1_USR_MIN_LOW_THR0 (at 0x3162)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR1"
      sgroup "VADC1_USR_MIN_LOW_THR1 (at 0x3163)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC1_USR_MIN_DATA0"
      sgroup "VADC1_USR_MIN_DATA0 (at 0x3166)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC1_USR_MIN_DATA1"
      sgroup "VADC1_USR_MIN_DATA1 (at 0x3167)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC1_USR_SEC_ACCESS"
      sgroup "VADC1_USR_SEC_ACCESS (at 0x31d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL1"
      sgroup "VADC1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL2"
      sgroup "VADC1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL3"
      sgroup "VADC1_USR_PERPH_RESET_CTL3 (at 0x31da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL4"
      sgroup "VADC1_USR_PERPH_RESET_CTL4 (at 0x31db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST1"
      sgroup "VADC1_USR_INT_TEST1 (at 0x31e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST_VAL"
      sgroup "VADC1_USR_INT_TEST_VAL (at 0x31e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_USR_TEST1_ADC_ANA_PARAM"
      sgroup "VADC1_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_USR_TEST2_ADC_DIG_PARAM"
      sgroup "VADC1_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_USR_TEST3_ADC_RSV"
      sgroup "VADC1_USR_TEST3_ADC_RSV (at 0x31e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_USR_TEST4_ADC_ATEST"
      sgroup "VADC1_USR_TEST4_ADC_ATEST (at 0x31e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_USR_TEST5_AMUX_ATEST"
      sgroup "VADC1_USR_TEST5_AMUX_ATEST (at 0x31e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_USR_TEST6_DTEST"
      sgroup "VADC1_USR_TEST6_DTEST (at 0x31e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_USR_TRIM_NUM"
      sgroup "VADC1_USR_TRIM_NUM (at 0x31f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_USR_TRIM1_ADC"
      sgroup "VADC1_USR_TRIM1_ADC (at 0x31f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_USR_TRIM1_AMUX"
      sgroup "VADC1_USR_TRIM1_AMUX (at 0x31f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM2_AMUX"
      sgroup "VADC1_USR_TRIM2_AMUX (at 0x31f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM4_AMUX"
      sgroup "VADC1_USR_TRIM4_AMUX (at 0x31f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_USR_TRIM5_AMUX"
      sgroup "VADC1_USR_TRIM5_AMUX (at 0x31f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "WLED1_CTRL"
  tree "WLED1_CTRL"
    tree "WLED1_CTRL_REVISION1"
      sgroup "WLED1_CTRL_REVISION1 (at 0x1d800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION2"
      sgroup "WLED1_CTRL_REVISION2 (at 0x1d801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION3"
      sgroup "WLED1_CTRL_REVISION3 (at 0x1d802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION4"
      sgroup "WLED1_CTRL_REVISION4 (at 0x1d803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_PERPH_TYPE"
      sgroup "WLED1_CTRL_PERPH_TYPE (at 0x1d804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_CTRL_PERPH_SUBTYPE"
      sgroup "WLED1_CTRL_PERPH_SUBTYPE (at 0x1d805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_CTRL_FAULT_STATUS"
      sgroup "WLED1_CTRL_FAULT_STATUS (at 0x1d808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RFU1                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU0                                     = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_RT_STS"
      sgroup "WLED1_CTRL_INT_RT_STS (at 0x1d810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_SET_TYPE"
      sgroup "WLED1_CTRL_INT_SET_TYPE (at 0x1d811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_HIGH"
      sgroup "WLED1_CTRL_INT_POLARITY_HIGH (at 0x1d812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_LOW"
      sgroup "WLED1_CTRL_INT_POLARITY_LOW (at 0x1d813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_CLR"
      sgroup "WLED1_CTRL_INT_LATCHED_CLR (at 0x1d814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_SET"
      sgroup "WLED1_CTRL_INT_EN_SET (at 0x1d815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_CLR"
      sgroup "WLED1_CTRL_INT_EN_CLR (at 0x1d816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_STS"
      sgroup "WLED1_CTRL_INT_LATCHED_STS (at 0x1d818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_PENDING_STS"
      sgroup "WLED1_CTRL_INT_PENDING_STS (at 0x1d819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_MID_SEL"
      sgroup "WLED1_CTRL_INT_MID_SEL (at 0x1d81a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_INT_PRIORITY"
      sgroup "WLED1_CTRL_INT_PRIORITY (at 0x1d81b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_AMOLED"
      sgroup "WLED1_CTRL_EN_AMOLED (at 0x1d844)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_AMOLED                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_MODULE_ENABLE"
      sgroup "WLED1_CTRL_MODULE_ENABLE (at 0x1d846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_FEEDBACK_CONTROL"
      sgroup "WLED1_CTRL_FEEDBACK_CONTROL (at 0x1d848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FEEDBACK_CONTROL                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_VREF_CONTROL"
      sgroup "WLED1_CTRL_VREF_CONTROL (at 0x1d849)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_CONTROL                             = "
    tree.end
    tree "WLED1_CTRL_BOOST_MAX_DUTY_CYCLE"
      sgroup "WLED1_CTRL_BOOST_MAX_DUTY_CYCLE (at 0x1d84b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY_CYCLE                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SWITCHING_FREQUENCY"
      sgroup "WLED1_CTRL_SWITCHING_FREQUENCY (at 0x1d84c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWITCHING_FREQ                           = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP"
      sgroup "WLED1_CTRL_WLED_OVP (at 0x1d84d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WLED_OVP                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_ILIM"
      sgroup "WLED1_CTRL_WLED_ILIM (at 0x1d84e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WLED_ILIM                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SLOPE_COMP_CAP"
      sgroup "WLED1_CTRL_SLOPE_COMP_CAP (at 0x1d850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SLOPE_COMP_ADJ"
      sgroup "WLED1_CTRL_SLOPE_COMP_ADJ (at 0x1d851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SLOPE_COMP_ADJ                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY"
      sgroup "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY (at 0x1d852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BIAS_GEN_WARMUP_DELAY                    = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SOFTSTART_RAMP_DELAY"
      sgroup "WLED1_CTRL_SOFTSTART_RAMP_DELAY (at 0x1d853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SOFTSTART_RAMP_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SW_SLEW_RATE_CONTROL"
      sgroup "WLED1_CTRL_SW_SLEW_RATE_CONTROL (at 0x1d854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SW_SLEW_RATE_CONTROL                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_RES"
      sgroup "WLED1_CTRL_VLOOP_COMP_RES (at 0x1d855)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_GM"
      sgroup "WLED1_CTRL_VLOOP_COMP_GM (at 0x1d856)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_EA_GM                               = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_CAP"
      sgroup "WLED1_CTRL_VLOOP_COMP_CAP (at 0x1d857)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_CAP                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_HCAP"
      sgroup "WLED1_CTRL_VLOOP_COMP_HCAP (at 0x1d858)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_HCAP                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_EN_HW_BL_REDN"
      sgroup "WLED1_CTRL_EN_HW_BL_REDN (at 0x1d859)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HW_BL_REDN                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_PSM"
      sgroup "WLED1_CTRL_EN_PSM (at 0x1d85a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PSM                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PSM_CTRL"
      sgroup "WLED1_CTRL_PSM_CTRL (at 0x1d85b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PSM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_PSM                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_WLED_PFM"
      sgroup "WLED1_CTRL_WLED_PFM (at 0x1d85d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_ILIM                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_TOFF                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_SHORT_PROTECT"
      sgroup "WLED1_CTRL_WLED_SHORT_PROTECT (at 0x1d85e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SC                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_DSCHGR                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DBNC_SHORT                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CTL                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_SEC_ACCESS"
      sgroup "WLED1_CTRL_SEC_ACCESS (at 0x1d8d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL1"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL1 (at 0x1d8d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL2"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL2 (at 0x1d8d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL3"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL3 (at 0x1d8da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL4"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL4 (at 0x1d8db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_SPARE"
      sgroup "WLED1_CTRL_SPARE (at 0x1d8df)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "WLED1_CTRL_INT_TEST1"
      sgroup "WLED1_CTRL_INT_TEST1 (at 0x1d8e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_TEST_VAL"
      sgroup "WLED1_CTRL_INT_TEST_VAL (at 0x1d8e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TEST_VAL                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST1"
      sgroup "WLED1_CTRL_TEST1 (at 0x1d8e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST2"
      sgroup "WLED1_CTRL_TEST2 (at 0x1d8e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST3"
      sgroup "WLED1_CTRL_TEST3 (at 0x1d8e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDSON_TM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   T_ERRAMP_OUT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVP_EN_MASK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_EN_MASK                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_REF_EN_MASK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIM_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ERRAMP_EN_MASK                           = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST4"
      sgroup "WLED1_CTRL_TEST4 (at 0x1d8e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FUTURE_USE                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_VREF_UP                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CLAMP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEBOUNCE_BYPASS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SLEEP_CLK_REQUEST                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOFT_START                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENB_IIND_UP                              = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST5"
      sgroup "WLED1_CTRL_TEST5 (at 0x1d8e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FUTURE_USE                               = "
    tree.end
    tree "WLED1_CTRL_TRIM_NUM"
      sgroup "WLED1_CTRL_TRIM_NUM (at 0x1d8f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_CTRL_TRIM_ILIM"
      sgroup "WLED1_CTRL_TRIM_ILIM (at 0x1d8f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_ILIM                                = "
    tree.end
    tree "WLED1_CTRL_REF_7P7_TRIM"
      sgroup "WLED1_CTRL_REF_7P7_TRIM (at 0x1d8f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REF_7P7_TRIM                             = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP_TRIM"
      sgroup "WLED1_CTRL_WLED_OVP_TRIM (at 0x1d8f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OVP_REF_TRIM                             = "
    tree.end
    tree "WLED1_CTRL_WLED_REF_TRIM"
      sgroup "WLED1_CTRL_WLED_REF_TRIM (at 0x1d8f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_WLED_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "WLED1_SINK"
  tree "WLED1_SINK"
    tree "WLED1_SINK_REVISION1"
      sgroup "WLED1_SINK_REVISION1 (at 0x1d900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION2"
      sgroup "WLED1_SINK_REVISION2 (at 0x1d901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION3"
      sgroup "WLED1_SINK_REVISION3 (at 0x1d902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION4"
      sgroup "WLED1_SINK_REVISION4 (at 0x1d903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_PERPH_TYPE"
      sgroup "WLED1_SINK_PERPH_TYPE (at 0x1d904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_SINK_PERPH_SUBTYPE"
      sgroup "WLED1_SINK_PERPH_SUBTYPE (at 0x1d905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_SINK_CURRENT_SINK_EN"
      sgroup "WLED1_SINK_CURRENT_SINK_EN (at 0x1d946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_SINK4                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CURRENT_SINK3                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_CURRENT_SINK2                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CURRENT_SINK1                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_ILED_SYNC_BIT"
      sgroup "WLED1_SINK_ILED_SYNC_BIT (at 0x1d947)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC_LED4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_LED3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_LED2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_LED1                                = " "0, 1"
    tree.end
    tree "WLED1_SINK_DIG_DIM_CLK_SEL"
      sgroup "WLED1_SINK_DIG_DIM_CLK_SEL (at 0x1d948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIG_DIM_CLK_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SINK_MODULATION_SCHEME"
      sgroup "WLED1_SINK_MODULATION_SCHEME (at 0x1d94a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODULATOR_CLOCK_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PHASE_STAGGERING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ACCUMULATOR_CLOCK_SEL                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HYBRID_DIMMING                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INTERNAL_MOD_RESOLUTION                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIMMING_METHOD                           = " "0, 1"
    tree.end
    tree "WLED1_SINK_HYBRID_DIMMING_TRESH"
      sgroup "WLED1_SINK_HYBRID_DIMMING_TRESH (at 0x1d94b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HYBRID_DIM_THRESH                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_EN"
      sgroup "WLED1_SINK_LED1_MODULATOR_EN (at 0x1d950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED1_IDAC_SYNC_DELAY (at 0x1d951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED1_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED1_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED1_FULL_SCALE_CURRENT (at 0x1d952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED1_MODULATOR_SRC_SEL (at 0x1d953)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_CABC_EN"
      sgroup "WLED1_SINK_LED1_CABC_EN (at 0x1d956)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB (at 0x1d957)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB (at 0x1d958)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_EN"
      sgroup "WLED1_SINK_LED2_MODULATOR_EN (at 0x1d960)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED2_IDAC_SYNC_DELAY (at 0x1d961)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED2_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED2_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED2_FULL_SCALE_CURRENT (at 0x1d962)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED2_MODULATOR_SRC_SEL (at 0x1d963)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_CABC_EN"
      sgroup "WLED1_SINK_LED2_CABC_EN (at 0x1d966)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB (at 0x1d967)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB (at 0x1d968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_EN"
      sgroup "WLED1_SINK_LED3_MODULATOR_EN (at 0x1d970)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED3_IDAC_SYNC_DELAY (at 0x1d971)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED3_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED3_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED3_FULL_SCALE_CURRENT (at 0x1d972)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED3_MODULATOR_SRC_SEL (at 0x1d973)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED3_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_CABC_EN"
      sgroup "WLED1_SINK_LED3_CABC_EN (at 0x1d976)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB (at 0x1d977)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED3_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB (at 0x1d978)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_EN"
      sgroup "WLED1_SINK_LED4_MODULATOR_EN (at 0x1d980)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED4_IDAC_SYNC_DELAY (at 0x1d981)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED4_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED4_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED4_FULL_SCALE_CURRENT (at 0x1d982)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED4_MODULATOR_SRC_SEL (at 0x1d983)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED4_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_CABC_EN"
      sgroup "WLED1_SINK_LED4_CABC_EN (at 0x1d986)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB (at 0x1d987)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED4_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB (at 0x1d988)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_SEC_ACCESS"
      sgroup "WLED1_SINK_SEC_ACCESS (at 0x1d9d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL1"
      sgroup "WLED1_SINK_PERPH_RESET_CTL1 (at 0x1d9d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL2"
      sgroup "WLED1_SINK_PERPH_RESET_CTL2 (at 0x1d9d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL3"
      sgroup "WLED1_SINK_PERPH_RESET_CTL3 (at 0x1d9da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL4"
      sgroup "WLED1_SINK_PERPH_RESET_CTL4 (at 0x1d9db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_SPARE"
      sgroup "WLED1_SINK_SPARE (at 0x1d9df)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "WLED1_SINK_TEST5"
      sgroup "WLED1_SINK_TEST5 (at 0x1d9e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CS_TGATE_ATEST                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CS_GATE_DRV_THRESH                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_HVG_PULL_STR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CS_OTA_COMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CS_FSTON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_FASTOTA                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_MAN_CAL_CTL"
      sgroup "WLED1_SINK_MAN_CAL_CTL (at 0x1d9e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_CS_OTA_CAL_EN                        = " "0, 1"
    tree.end
    tree "WLED1_SINK_TRIM_NUM"
      sgroup "WLED1_SINK_TRIM_NUM (at 0x1d9f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED1"
      sgroup "WLED1_SINK_TRIM_VREF_ILED1 (at 0x1d9f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED1                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED2"
      sgroup "WLED1_SINK_TRIM_VREF_ILED2 (at 0x1d9f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED2                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED3"
      sgroup "WLED1_SINK_TRIM_VREF_ILED3 (at 0x1d9f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED3                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED4"
      sgroup "WLED1_SINK_TRIM_VREF_ILED4 (at 0x1d9f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED4                          = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED1"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED1 (at 0x1d9f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED1                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED2"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED2 (at 0x1d9f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED2                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED3"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED3 (at 0x1d9f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED3                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED4"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED4 (at 0x1d9f8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED4                        = "
    tree.end
  tree.end
tree.end

