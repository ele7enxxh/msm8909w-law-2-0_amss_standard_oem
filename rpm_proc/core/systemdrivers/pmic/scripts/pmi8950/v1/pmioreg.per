entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BSI"
  tree "BSI"
    tree "BSI_REVISION1"
      sgroup "BSI_REVISION1 (at 0x1b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BSI_REVISION2"
      sgroup "BSI_REVISION2 (at 0x1b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BSI_REVISION3"
      sgroup "BSI_REVISION3 (at 0x1b02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BSI_REVISION4"
      sgroup "BSI_REVISION4 (at 0x1b03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BSI_PERPH_TYPE"
      sgroup "BSI_PERPH_TYPE (at 0x1b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BSI_PERPH_SUBTYPE"
      sgroup "BSI_PERPH_SUBTYPE (at 0x1b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BSI_BSI_STS"
      sgroup "BSI_BSI_STS (at 0x1b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_ACTIVE                               = " "0 (BSI_NOT_ACTIVE),1 (BSI_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BSI_TX_DISABLE                           = " "0 (TX_ENABLED),1 (TX_DISABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_ERR_FLAG                        = " "0 (OK),1 (ERROR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_TX_BUSY                         = " "0 (TX_IDLE),1 (TX_BUSY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_RX_BUSY                         = " "0 (RX_IDLE),1 (RX_BUSY)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_TX_GO_STATUS                    = " "0 (TX_GO_CLEAR),1 (TX_GO_SET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_RX_FLOW_STATUS                  = " "0 (NO_RX_DATA),1 (RX_DATA_AVAIL)"
    tree.end
    tree "BSI_MIPI_BIF_FSM_STS"
      sgroup "BSI_MIPI_BIF_FSM_STS (at 0x1b09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MIPI_BIF_TX_FSM                          = " "0 (TX_IDLE),1 (TX_DATA_STATE),2 (TX_STOP),3 (TX_BAT_IRQ),4 (TX_PUL),5 (TX_WAIT_CLR_ERR),6 (TX_DLY_STATE),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_RX_FSM                          = " "0 (RX_IDLE),1 (RX_BCF),2 (RX_NOT_BCF),3 (RX_DATA_STATE),4 (RX_STOP),5 (RX_BAT_IRQ),6 (RX_WAIT_CLR_ERR),7 (reserved)"
    tree.end
    tree "BSI_RX_FIFO_STS"
      sgroup "BSI_RX_FIFO_STS (at 0x1b0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WORD_NUM                                 = "
    tree.end
    tree "BSI_BSI_BAT_STS"
      sgroup "BSI_BSI_BAT_STS (at 0x1b0d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISS_DEB                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_RAW                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_DEB_PRES_STATUS                      = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_NODEB_PRES_STATUS                    = " "0 (BATT_PRESENT),1 (BATT_GONE)"
    tree.end
    tree "BSI_INT_RT_STS"
      sgroup "BSI_INT_RT_STS (at 0x1b10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_RT_STS                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BSI_INT_SET_TYPE"
      sgroup "BSI_INT_SET_TYPE (at 0x1b11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BSI_INT_POLARITY_HIGH"
      sgroup "BSI_INT_POLARITY_HIGH (at 0x1b12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_HIGH               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_HIGH             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_HIGH           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_POLARITY_LOW"
      sgroup "BSI_INT_POLARITY_LOW (at 0x1b13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_LOW                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_LOW              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_LOW            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_CLR"
      sgroup "BSI_INT_LATCHED_CLR (at 0x1b14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "BSI_INT_EN_SET"
      sgroup "BSI_INT_EN_SET (at 0x1b15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_EN_CLR"
      sgroup "BSI_INT_EN_CLR (at 0x1b16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_STS"
      sgroup "BSI_INT_LATCHED_STS (at 0x1b18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BSI_INT_PENDING_STS"
      sgroup "BSI_INT_PENDING_STS (at 0x1b19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BSI_INT_MID_SEL"
      sgroup "BSI_INT_MID_SEL (at 0x1b1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BSI_INT_PRIORITY"
      sgroup "BSI_INT_PRIORITY (at 0x1b1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BSI_BSI_EN"
      sgroup "BSI_BSI_EN (at 0x1b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_EN                                   = " "0 (BSI_DISABLED),1 (BSI_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_ERR_CLEAR"
      sgroup "BSI_MIPI_BIF_ERR_CLEAR (at 0x1b4f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_CLEAR_ERR                       = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FSM_RESET"
      sgroup "BSI_MIPI_BIF_FSM_RESET (at 0x1b50)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FSM_RESET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_FIFO_RESET                   = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FORCE_BCL_LOW"
      sgroup "BSI_MIPI_BIF_FORCE_BCL_LOW (at 0x1b51)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FORCE_BCL_LOW                   = " "0 (BCL_RELEASED),1 (BCL_FORCED_LOW)"
    tree.end
    tree "BSI_MIPI_BIF_TAU_CFG"
      sgroup "BSI_MIPI_BIF_TAU_CFG (at 0x1b52)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_SAMPLE_RATE                     = " "0 (SAMPLE_RATE_4X),1 (SAMPLE_RATE_8X)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_SEL_TAU                         = " "0 (TAU_150US),1 (TAU_122US),2 (TAU_62US),3 (TAU_32US),4 (TAU_16US),5 (TAU_8US),6 (TAU_4US),7 (TAU_2US)"
    tree.end
    tree "BSI_MIPI_BIF_MODE"
      sgroup "BSI_MIPI_BIF_MODE (at 0x1b53)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_TX_PULSE_MODE                   = " "0 (TX_DATA_MODE),1 (TX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_RX_PULSE_MODE                   = " "0 (RX_DATA_MODE),1 (RX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_PULSE_TYPE                   = " "0 (TX_PULSE_1_TAU),1 (TX_PULSE_240US)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_DATA_FORMAT                  = " "0 (RX_11BIT_MODE),1 (RX_17BIT_MODE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_DATA_FORMAT                  = " "0 (TX_11BIT_MODE),1 (TX_17BIT_MODE)"
    tree.end
    tree "BSI_MIPI_BIF_EN"
      sgroup "BSI_MIPI_BIF_EN (at 0x1b54)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_TX_EN                           = " "0 (TX_DISABLED),1 (TX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_EN                           = " "0 (RX_DISABLED),1 (RX_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_CFG"
      sgroup "BSI_MIPI_BIF_CFG (at 0x1b55)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_PU_EN                           = " "0 (PULLUP_DISABLED),1 (PULLUP_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_RX_CFG"
      sgroup "BSI_MIPI_BIF_RX_CFG (at 0x1b56)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_EN                                  = " "0 (FIFO_DISABLED),1 (FIFO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_IRQ_FREQ                              = " "0 (FREQ_1_WORD),1 (FREQ_2_WORDS),2 (FREQ_3_WORDS),3 (FREQ_4_WORDS),4 (FREQ_5_WORDS),5 (FREQ_6_WORDS),6 (FREQ_7_WORDS),7 (FREQ_8_WORDS)"
    tree.end
    tree "BSI_MIPI_BIF_TX_DLY"
      sgroup "BSI_MIPI_BIF_TX_DLY (at 0x1b59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIPI_BIF_TX_DLY                          = " "0 (DLY_0_TAU),1 (DLY_5_TAU),2 (DLY_10_TAU),3 (DLY_15_TAU)"
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_0"
      sgroup "BSI_MIPI_BIF_DATA_TX_0 (at 0x1b5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_1"
      sgroup "BSI_MIPI_BIF_DATA_TX_1 (at 0x1b5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_2"
      sgroup "BSI_MIPI_BIF_DATA_TX_2 (at 0x1b5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_TX                         = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_TX_CTL"
      sgroup "BSI_MIPI_BIF_TX_CTL (at 0x1b5d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_GO                           = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_0"
      sgroup "BSI_MIPI_BIF_DATA_RX_0 (at 0x1b60)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_1"
      sgroup "BSI_MIPI_BIF_DATA_RX_1 (at 0x1b61)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_2"
      sgroup "BSI_MIPI_BIF_DATA_RX_2 (at 0x1b62)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_DATA_LOOPBACK_TAG               = " "0 (NORMAL_DATA),1 (LOOPBACK_DATA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_RX                         = " "0, 1"
    tree.end
    tree "BSI_RX_FIFO_WORD1_0"
      sgroup "BSI_RX_FIFO_WORD1_0 (at 0x1b63)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD1_1"
      sgroup "BSI_RX_FIFO_WORD1_1 (at 0x1b64)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD2_0"
      sgroup "BSI_RX_FIFO_WORD2_0 (at 0x1b65)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD2_1"
      sgroup "BSI_RX_FIFO_WORD2_1 (at 0x1b66)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD3_0"
      sgroup "BSI_RX_FIFO_WORD3_0 (at 0x1b67)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD3_1"
      sgroup "BSI_RX_FIFO_WORD3_1 (at 0x1b68)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD4_0"
      sgroup "BSI_RX_FIFO_WORD4_0 (at 0x1b69)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD4_1"
      sgroup "BSI_RX_FIFO_WORD4_1 (at 0x1b6a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_MIPI_BIF_BCL_RAW"
      sgroup "BSI_MIPI_BIF_BCL_RAW (at 0x1b6d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_BCL_RAW                         = " "0 (BCL_STATE_LOW),1 (BCL_STATE_HIGH)"
    tree.end
    tree "BSI_MIPI_BIF_ERROR"
      sgroup "BSI_MIPI_BIF_ERROR (at 0x1b70)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MIPI_BIF_ERROR_CODE                      = "
    tree.end
    tree "BSI_BAT_GONE_CFG"
      sgroup "BSI_BAT_GONE_CFG (at 0x1ba7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_GONE_SEL                             = " "0 (NON_DEBOUNCED),1 (DEBOUNCED)"
    tree.end
    tree "BSI_BAT_RMV_DEB_TIMER"
      sgroup "BSI_BAT_RMV_DEB_TIMER (at 0x1ba8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RMV_TIMER                                = "
    tree.end
    tree "BSI_BAT_PRES_DEB_TIMER"
      sgroup "BSI_BAT_PRES_DEB_TIMER (at 0x1ba9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PRES_TIMER                               = "
    tree.end
    tree "BSI_BAT_GONE_DLY"
      sgroup "BSI_BAT_GONE_DLY (at 0x1baa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801baa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1baa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DLY_CFG                                  = " "0 (BYPASSED),1 (DLY_10U3),2 (DLY_15U6),3 (DLY_19U6)"
    tree.end
    tree "BSI_SEC_ACCESS"
      sgroup "BSI_SEC_ACCESS (at 0x1bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BSI_PERPH_RESET_CTL2"
      sgroup "BSI_PERPH_RESET_CTL2 (at 0x1bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL3"
      sgroup "BSI_PERPH_RESET_CTL3 (at 0x1bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL4"
      sgroup "BSI_PERPH_RESET_CTL4 (at 0x1bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BSI_BSI_SPARE"
      sgroup "BSI_BSI_SPARE (at 0x1bdf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "BSI_INT_TEST1"
      sgroup "BSI_INT_TEST1 (at 0x1be0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BSI_INT_TEST_VAL"
      sgroup "BSI_INT_TEST_VAL (at 0x1be1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_INT_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_INT_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BSI_TEST1"
      sgroup "BSI_TEST1 (at 0x1be2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "BSI_TEST2"
      sgroup "BSI_TEST2 (at 0x1be3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   BSI_DTEST_SEL                            = "
    tree.end
    tree "BSI_MIPI_BIF_TX_ATE_CTL"
      sgroup "BSI_MIPI_BIF_TX_ATE_CTL (at 0x1be4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_GO_ATE                                = " "0, 1"
    tree.end
    tree "BSI_BSI_TEST"
      sgroup "BSI_BSI_TEST (at 0x1be5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DISABLE_TEST                          = " "0 (NORMAL),1 (IGNORED)"
    tree.end
  tree.end
tree.end
tree "BUA"
  tree "BUA"
    tree "BUA_REVISION1"
      sgroup "BUA_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_REVISION2"
      sgroup "BUA_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_REVISION3"
      sgroup "BUA_REVISION3 (at 0x1c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_REVISION4"
      sgroup "BUA_REVISION4 (at 0x1c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_PERPH_TYPE"
      sgroup "BUA_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_PERPH_SUBTYPE"
      sgroup "BUA_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_STATUS1"
      sgroup "BUA_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_BUA_CTL1"
      sgroup "BUA_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0 (SCLK_0_TO_1),1 (SCLK_1_TO_2),2 (SCLK_2_TO_3),3 (SCLK_5_TO_6),4 (SCLK_8_TO_9),5 (SCLK_11_TO_12),6 (SCLK_15_TO_16),7 (SCLK_31_TO_32)"
    tree.end
    tree "BUA_EN_CTL1"
      sgroup "BUA_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_SEC_ACCESS"
      sgroup "BUA_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_PERPH_RESET_CTL1"
      sgroup "BUA_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUA_PERPH_RESET_CTL2"
      sgroup "BUA_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL3"
      sgroup "BUA_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL4"
      sgroup "BUA_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUA_TEST1"
      sgroup "BUA_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0 (ALT_SC_DIVIDER_DIS),1 (ALT_SC_DIVIDER_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "FG_ADC_MDM"
  tree "FG_ADC_MDM"
    tree "FG_ADC_MDM_PERPH_TYPE"
      sgroup "FG_ADC_MDM_PERPH_TYPE (at 0x4304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_ADC_MDM_PERPH_SUBTYPE"
      sgroup "FG_ADC_MDM_PERPH_SUBTYPE (at 0x4305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_ADC_MDM_INT_RT_STS"
      sgroup "FG_ADC_MDM_INT_RT_STS (at 0x4310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_ADC_MDM_INT_SET_TYPE"
      sgroup "FG_ADC_MDM_INT_SET_TYPE (at 0x4311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_ADC_MDM_INT_POLARITY_HIGH"
      sgroup "FG_ADC_MDM_INT_POLARITY_HIGH (at 0x4312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_POLARITY_LOW"
      sgroup "FG_ADC_MDM_INT_POLARITY_LOW (at 0x4313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_LATCHED_CLR"
      sgroup "FG_ADC_MDM_INT_LATCHED_CLR (at 0x4314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_INT_EN_SET"
      sgroup "FG_ADC_MDM_INT_EN_SET (at 0x4315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_EN_CLR"
      sgroup "FG_ADC_MDM_INT_EN_CLR (at 0x4316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_LATCHED_STS"
      sgroup "FG_ADC_MDM_INT_LATCHED_STS (at 0x4318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_ADC_MDM_INT_PENDING_STS"
      sgroup "FG_ADC_MDM_INT_PENDING_STS (at 0x4319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_ADC_MDM_INT_MID_SEL"
      sgroup "FG_ADC_MDM_INT_MID_SEL (at 0x431a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_ADC_MDM_INT_PRIORITY"
      sgroup "FG_ADC_MDM_INT_PRIORITY (at 0x431b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_ADC_MDM_EN_CTL"
      sgroup "FG_ADC_MDM_EN_CTL (at 0x4346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_ADC_EN                                = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
    tree.end
    tree "FG_ADC_MDM_ACCESS_BAT_REQ"
      sgroup "FG_ADC_MDM_ACCESS_BAT_REQ (at 0x4350)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (ACC_NOT_REQUESTED),1 (O59ACC_REQUESTED)"
    tree.end
    tree "FG_ADC_MDM_ACCESS_BAT_GRNT"
      sgroup "FG_ADC_MDM_ACCESS_BAT_GRNT (at 0x4351)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STS                                      = " "0 (ACC_NOT_GRANTED),1 (ACC_GRANTED)"
    tree.end
    tree "FG_ADC_MDM_BCL_VALUES"
      sgroup "FG_ADC_MDM_BCL_VALUES (at 0x4353)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT"
      sgroup "FG_ADC_MDM_VBAT (at 0x4354)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT"
      sgroup "FG_ADC_MDM_IBAT (at 0x4355)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_CP"
      sgroup "FG_ADC_MDM_VBAT_CP (at 0x4356)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_CP"
      sgroup "FG_ADC_MDM_IBAT_CP (at 0x4357)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN"
      sgroup "FG_ADC_MDM_VBAT_MIN (at 0x4358)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX"
      sgroup "FG_ADC_MDM_IBAT_MAX (at 0x4359)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN_CP"
      sgroup "FG_ADC_MDM_VBAT_MIN_CP (at 0x435a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80435a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x435a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX_CP"
      sgroup "FG_ADC_MDM_IBAT_MAX_CP (at 0x435b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80435b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x435b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BAT_RES_7_0"
      sgroup "FG_ADC_MDM_BAT_RES_7_0 (at 0x435c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80435c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x435c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BAT_RES_15_8"
      sgroup "FG_ADC_MDM_BAT_RES_15_8 (at 0x435d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80435d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x435d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_MODE"
      sgroup "FG_ADC_MDM_BCL_MODE (at 0x435e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80435e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x435e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   STS                                      = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM),2 (BCL_IS_MPM),3 (BCL_IS_INVALID_MODE)"
    tree.end
    tree "FG_ADC_MDM_BCL_V_GAIN_BATT"
      sgroup "FG_ADC_MDM_BCL_V_GAIN_BATT (at 0x4360)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_GAIN_RSENSE"
      sgroup "FG_ADC_MDM_BCL_I_GAIN_RSENSE (at 0x4361)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_OFFSET_RSENSE"
      sgroup "FG_ADC_MDM_BCL_I_OFFSET_RSENSE (at 0x4362)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_GAIN_BATFET"
      sgroup "FG_ADC_MDM_BCL_I_GAIN_BATFET (at 0x4363)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_OFFSET_BATFET"
      sgroup "FG_ADC_MDM_BCL_I_OFFSET_BATFET (at 0x4364)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_SENSE_SOURCE"
      sgroup "FG_ADC_MDM_BCL_I_SENSE_SOURCE (at 0x4365)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STS                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN_CLR"
      sgroup "FG_ADC_MDM_VBAT_MIN_CLR (at 0x4366)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX_CLR"
      sgroup "FG_ADC_MDM_IBAT_MAX_CLR (at 0x4367)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT_INT"
      sgroup "FG_ADC_MDM_VBAT_INT (at 0x4368)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_INT"
      sgroup "FG_ADC_MDM_IBAT_INT (at 0x4369)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_MDM_SEC_ACCESS"
      sgroup "FG_ADC_MDM_SEC_ACCESS (at 0x43d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL2"
      sgroup "FG_ADC_MDM_PERPH_RESET_CTL2 (at 0x43d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL3"
      sgroup "FG_ADC_MDM_PERPH_RESET_CTL3 (at 0x43da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL4"
      sgroup "FG_ADC_MDM_PERPH_RESET_CTL4 (at 0x43db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_ADC_MDM_INT_TEST1"
      sgroup "FG_ADC_MDM_INT_TEST1 (at 0x43e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_TEST_VAL"
      sgroup "FG_ADC_MDM_INT_TEST_VAL (at 0x43e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "FG_ADC_USR"
  tree "FG_ADC_USR"
    tree "FG_ADC_USR_PERPH_TYPE"
      sgroup "FG_ADC_USR_PERPH_TYPE (at 0x4204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_ADC_USR_PERPH_SUBTYPE"
      sgroup "FG_ADC_USR_PERPH_SUBTYPE (at 0x4205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_ADC_USR_INT_RT_STS"
      sgroup "FG_ADC_USR_INT_RT_STS (at 0x4210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_ADC_USR_INT_SET_TYPE"
      sgroup "FG_ADC_USR_INT_SET_TYPE (at 0x4211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_ADC_USR_INT_POLARITY_HIGH"
      sgroup "FG_ADC_USR_INT_POLARITY_HIGH (at 0x4212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_POLARITY_LOW"
      sgroup "FG_ADC_USR_INT_POLARITY_LOW (at 0x4213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_LATCHED_CLR"
      sgroup "FG_ADC_USR_INT_LATCHED_CLR (at 0x4214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "FG_ADC_USR_INT_EN_SET"
      sgroup "FG_ADC_USR_INT_EN_SET (at 0x4215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_EN_CLR"
      sgroup "FG_ADC_USR_INT_EN_CLR (at 0x4216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_LATCHED_STS"
      sgroup "FG_ADC_USR_INT_LATCHED_STS (at 0x4218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_ADC_USR_INT_PENDING_STS"
      sgroup "FG_ADC_USR_INT_PENDING_STS (at 0x4219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_ADC_USR_INT_MID_SEL"
      sgroup "FG_ADC_USR_INT_MID_SEL (at 0x421a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_ADC_USR_INT_PRIORITY"
      sgroup "FG_ADC_USR_INT_PRIORITY (at 0x421b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_ADC_USR_EN_CTL"
      sgroup "FG_ADC_USR_EN_CTL (at 0x4246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_ADC_EN                                = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
    tree.end
    tree "FG_ADC_USR_ACCESS_BAT_REQ"
      sgroup "FG_ADC_USR_ACCESS_BAT_REQ (at 0x4250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (ACC_NOT_REQUESTED),1 (O59ACC_REQUESTED)"
    tree.end
    tree "FG_ADC_USR_ACCESS_BAT_GRNT"
      sgroup "FG_ADC_USR_ACCESS_BAT_GRNT (at 0x4251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STS                                      = " "0 (ACC_NOT_GRANTED),1 (ACC_GRANTED)"
    tree.end
    tree "FG_ADC_USR_BCL_VALUES"
      sgroup "FG_ADC_USR_BCL_VALUES (at 0x4253)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT"
      sgroup "FG_ADC_USR_VBAT (at 0x4254)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT"
      sgroup "FG_ADC_USR_IBAT (at 0x4255)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_CP"
      sgroup "FG_ADC_USR_VBAT_CP (at 0x4256)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_CP"
      sgroup "FG_ADC_USR_IBAT_CP (at 0x4257)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_MIN"
      sgroup "FG_ADC_USR_VBAT_MIN (at 0x4258)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_MAX"
      sgroup "FG_ADC_USR_IBAT_MAX (at 0x4259)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_MIN_CP"
      sgroup "FG_ADC_USR_VBAT_MIN_CP (at 0x425a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_MAX_CP"
      sgroup "FG_ADC_USR_IBAT_MAX_CP (at 0x425b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BAT_RES_7_0"
      sgroup "FG_ADC_USR_BAT_RES_7_0 (at 0x425c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BAT_RES_15_8"
      sgroup "FG_ADC_USR_BAT_RES_15_8 (at 0x425d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_MODE"
      sgroup "FG_ADC_USR_BCL_MODE (at 0x425e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   STS                                      = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM),2 (BCL_IS_MPM),3 (BCL_IS_INVALID_MODE)"
    tree.end
    tree "FG_ADC_USR_BCL_V_GAIN_BATT"
      sgroup "FG_ADC_USR_BCL_V_GAIN_BATT (at 0x4260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_GAIN_RSENSE"
      sgroup "FG_ADC_USR_BCL_I_GAIN_RSENSE (at 0x4261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_OFFSET_RSENSE"
      sgroup "FG_ADC_USR_BCL_I_OFFSET_RSENSE (at 0x4262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_GAIN_BATFET"
      sgroup "FG_ADC_USR_BCL_I_GAIN_BATFET (at 0x4263)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_OFFSET_BATFET"
      sgroup "FG_ADC_USR_BCL_I_OFFSET_BATFET (at 0x4264)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_SENSE_SOURCE"
      sgroup "FG_ADC_USR_BCL_I_SENSE_SOURCE (at 0x4265)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STS                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT_MIN_CLR"
      sgroup "FG_ADC_USR_VBAT_MIN_CLR (at 0x4266)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_IBAT_MAX_CLR"
      sgroup "FG_ADC_USR_IBAT_MAX_CLR (at 0x4267)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT_INT"
      sgroup "FG_ADC_USR_VBAT_INT (at 0x4268)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_INT"
      sgroup "FG_ADC_USR_IBAT_INT (at 0x4269)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_USR_SEC_ACCESS"
      sgroup "FG_ADC_USR_SEC_ACCESS (at 0x42d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL2"
      sgroup "FG_ADC_USR_PERPH_RESET_CTL2 (at 0x42d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL3"
      sgroup "FG_ADC_USR_PERPH_RESET_CTL3 (at 0x42da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL4"
      sgroup "FG_ADC_USR_PERPH_RESET_CTL4 (at 0x42db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_ADC_USR_INT_TEST1"
      sgroup "FG_ADC_USR_INT_TEST1 (at 0x42e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_TEST_VAL"
      sgroup "FG_ADC_USR_INT_TEST_VAL (at 0x42e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "FG_BATT"
  tree "FG_BATT"
    tree "FG_BATT_PERPH_TYPE"
      sgroup "FG_BATT_PERPH_TYPE (at 0x4104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_BATT_PERPH_SUBTYPE"
      sgroup "FG_BATT_PERPH_SUBTYPE (at 0x4105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_BATT_BATTERY"
      sgroup "FG_BATT_BATTERY (at 0x4106)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID                                       = " "0, 1, 2, 3"
    tree.end
    tree "FG_BATT_SYS_BATT"
      sgroup "FG_BATT_SYS_BATT (at 0x4107)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   STS                                      = " "0 (ISMISSING),1 (CHARGING_CV),2 (CHARGING_CC),3 (SYSTEM_FULL),4 (DISCHARGING),5 (AUTOMATIC_RECHARGE),6 (SUPPLEMENTAL),7 (EMPTY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_REMOVED_LATCHED_STS                 = " "0 (BATT_PRESENT),1 (BATT_REMOVED_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_LOW_RT_STS                          = " "0 (BATT_VOLTAGE_NORMAL),1 (BATT_VOLTAGE_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_PROFILE_STS                         = " "0 (BATT_PROFILE_ORIGINAL),1 (BATT_PROFILE_CHANGED)"
    tree.end
    tree "FG_BATT_BATT_DET"
      sgroup "FG_BATT_BATT_DET (at 0x4108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERR                                      = " "0 (BATT_ID_DETECTION_OK),1 (BATT_ID_DETECTION_ERR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SMART                                    = " "0 (BATT_ID_DETECTION_NOT_SMART),1 (BATT_ID_DETECTION_SMART)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FLOAT                                    = " "0 (BATTERY_ID_NOT_FLOAT_TO_GND),1 (BATTERY_ID_FLOAT_TO_GND)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GND                                      = " "0 (BATT_ID_NOT_SHORTED_TO_GND),1 (BATT_ID_SHORTED_GND)"
    tree.end
    tree "FG_BATT_BATT_INFO_STS"
      sgroup "FG_BATT_BATT_INFO_STS (at 0x4109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ESR_UPDATE                               = " "0 (ESR_NOT_UPDATED_THIS_CYCLE),1 (ESR_UPDATED_THIS_CYCLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   JEITA_HARD_HOT_RT_STS                    = " "0 (JEITA_BELOW_HARD_HOT_THRESHOLD),1 (JEITA_ABOVE_HARD_HOT_THRESHOLD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_HARD_COLD_RT_STS                   = " "0 (JEITA_BELOW_HARD_COLD_THRESHOLD),1 (JEITA_ABOVE_HARD_COLD_THRESHOLD)"
    tree.end
    tree "FG_BATT_RECOVERY_STS"
      sgroup "FG_BATT_RECOVERY_STS (at 0x410a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80410a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RECOVERY_DATA_WAIT                       = " "0 (RECOVERY_DATA_NOT_WAIT),1 (RECOVERY_DATA_WAIT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RECOVERY_DATA_ACK                        = " "0 (RECOVERY_DATA_NOT_ACK),1 (RECOVERY_DATA_ACK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RECOVERY_TIMEOUT_STS                     = " "0 (RECOVERY_TIMEOUT_FALSE),1 (RECOVERY_TIMEOUT_TRUE)"
    tree.end
    tree "FG_BATT_INT_RT_STS"
      sgroup "FG_BATT_INT_RT_STS (at 0x4110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_RT_STS                        = " "0 (BATT_MATCH_RT_STS_FALSE),1 (BATT_MATCH_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_RT_STS                      = " "0 (BATT_MISSING_RT_STS_FALSE),1 (BATT_MISSING_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_RT_STS                      = " "0 (BATT_UNKNOWN_RT_STS_FALSE),1 (BATT_UNKNOWN_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_RT_STS                       = " "0 (BATT_ID_REQ_RT_STS_FALSE),1 (BATT_ID_REQ_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_RT_STS                      = " "0 (BATT_IDENTIFIED_RT_STS_FALSE),1 (BATT_IDENTIFIED_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_RT_STS                         = " "0 (VBATT_LOW_RT_STS_FALSE),1 (VBATT_LOW_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_RT_STS                    = " "0 (JEITA_SOFT_HOT_RT_STS_FALSE),1 (JEITA_SOFT_HOT_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_RT_STS                   = " "0 (JEITA_SOFT_COLD_RT_STS_FALSE),1 (JEITA_SOFT_COLD_RT_STS_TRUE)"
    tree.end
    tree "FG_BATT_INT_SET_TYPE"
      sgroup "FG_BATT_INT_SET_TYPE (at 0x4111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_SET_TYPE             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_BATT_INT_POLARITY_HIGH"
      sgroup "FG_BATT_INT_POLARITY_HIGH (at 0x4112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INT_POLARITY_LOW"
      sgroup "FG_BATT_INT_POLARITY_LOW (at 0x4113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INT_LATCHED_CLR"
      sgroup "FG_BATT_INT_LATCHED_CLR (at 0x4114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_CLR               = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_CLR              = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_CLR                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_CLR           = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_CLR          = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_INT_EN_SET"
      sgroup "FG_BATT_INT_EN_SET (at 0x4115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_SET               = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_SET             = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_SET             = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_SET              = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_LATCHED_SET             = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_SET                = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_SET           = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_SET          = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_BATT_INT_EN_CLR"
      sgroup "FG_BATT_INT_EN_CLR (at 0x4116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_EN_CLR                    = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_EN_CLR                   = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_EN_CLR                     = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_EN_CLR                = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_EN_CLR               = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_BATT_INT_LATCHED_STS"
      sgroup "FG_BATT_INT_LATCHED_STS (at 0x4118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_STS               = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_STS              = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_STS                = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_STS           = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_STS          = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_BATT_INT_PENDING_STS"
      sgroup "FG_BATT_INT_PENDING_STS (at 0x4119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_PENDING_STS               = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_PENDING_STS              = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_PENDING_STS                = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_PENDING_STS           = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_PENDING_STS          = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_BATT_INT_MID_SEL"
      sgroup "FG_BATT_INT_MID_SEL (at 0x411a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_BATT_INT_PRIORITY"
      sgroup "FG_BATT_INT_PRIORITY (at 0x411b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_BATT_SW_BATT_ID"
      sgroup "FG_BATT_SW_BATT_ID (at 0x4150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE                                    = " "0 (FORCE_BATID_FALSE),1 (FORCE_BATID_TRUE)"
    tree.end
    tree "FG_BATT_PROFILE_ID"
      sgroup "FG_BATT_PROFILE_ID (at 0x4151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM                                      = " "0 (SW_BATT_ID0),1 (SW_BATT_ID1),2 (SW_BATT_ID2),3 (SW_BATT_ID3)"
    tree.end
    tree "FG_BATT_BATT_REMOVED_LATCHED"
      sgroup "FG_BATT_BATT_REMOVED_LATCHED (at 0x4152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0 (BATT_REMOVED_LATCH_CLEAR_FALSE),1 (BATT_REMOVED_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_BATT_RECOVERY"
      sgroup "FG_BATT_BATT_RECOVERY (at 0x4153)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RECOVERY_DATA_RDY                        = " "0 (RECOVERY_DATA_RDY_FALSE),1 (RECOVERY_DATA_RDY_TRUE)"
    tree.end
    tree "FG_BATT_SEC_ACCESS"
      sgroup "FG_BATT_SEC_ACCESS (at 0x41d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL2"
      sgroup "FG_BATT_PERPH_RESET_CTL2 (at 0x41d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL3"
      sgroup "FG_BATT_PERPH_RESET_CTL3 (at 0x41da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL4"
      sgroup "FG_BATT_PERPH_RESET_CTL4 (at 0x41db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_BATT_INT_TEST1"
      sgroup "FG_BATT_INT_TEST1 (at 0x41e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_BATT_INT_TEST_VAL"
      sgroup "FG_BATT_INT_TEST_VAL (at 0x41e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_TEST_VAL                  = " "0 (BATT_MATCH_INT_TEST_VAL_FALSE),1 (BATT_MATCH_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_TEST_VAL                = " "0 (BATT_MISSING_INT_TEST_VAL_FALSE),1 (BATT_MISSING_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_TEST_VAL                = " "0 (BATT_UNKNOWN_INT_TEST_VAL_FALSE),1 (BATT_UNKNOWN_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_TEST_VAL                 = " "0 (BATT_ID_REQ_INT_TEST_VAL_FALSE),1 (BATT_ID_REQ_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_ID_DONE_INT_TEST_VAL                = " "0 (BATT_IDENTIFIED_INT_TEST_VAL_FALSE),1 (BATT_IDENTIFIED_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_TEST_VAL                   = " "0 (VBATT_LOW_INT_TEST_VAL_FALSE),1 (VBATT_LOW_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_TEST_VAL              = " "0 (JEITA_SOFT_HOT_INT_TEST_VAL_FALSE),1 (JEITA_SOFT_HOT_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_TEST_VAL             = " "0 (JEITA_SOFT_COLD_INT_TEST_VAL_FALSE),1 (JEITA_SOFT_COLD_INT_TEST_VAL_TRUE)"
    tree.end
    tree "FG_BATT_ESR_CHANGE_BOUND"
      sgroup "FG_BATT_ESR_CHANGE_BOUND (at 0x41e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOW_TEMP_RANGE                           = " "0 (ESR_LOW_TEMP_RANGE_FALSE),1 (ESR_LOW_TEMP_RANGE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPPER_HIT                                = " "0 (ESR_BELOW_HI_SATURATE_THRESH),1 (ESR_ABOVE_HI_SATURATE_THRESH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LOWER_HIT                                = " "0 (ESR_ABOVE_LO_SATURATE_THRESH),1 (ESR_BELOW_LO_SATURATE_THRESH)"
    tree.end
    tree "FG_BATT_PEEK_MUX1"
      sgroup "FG_BATT_PEEK_MUX1 (at 0x41eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX2"
      sgroup "FG_BATT_PEEK_MUX2 (at 0x41ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX3"
      sgroup "FG_BATT_PEEK_MUX3 (at 0x41ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX4"
      sgroup "FG_BATT_PEEK_MUX4 (at 0x41ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_DTEST_RDBACK"
      sgroup "FG_BATT_DTEST_RDBACK (at 0x41ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STS                                      = "
    tree.end
    tree "FG_BATT_TRIM_NUM"
      sgroup "FG_BATT_TRIM_NUM (at 0x41f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_BATT_MISC_CFG"
      sgroup "FG_BATT_MISC_CFG (at 0x41f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RECOVERY_DATA_EN                         = " "0 (RECOVERY_DATA_DISABLE),1 (RECOVERY_DATA_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RECOVERY_TIMEOUT_EN                      = " "0 (RECOVERY_TIMEOUT_DISABLE),1 (RECOVERY_TIMEOUT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMISTOR_CFG                           = " "0 (THERMISTOR_ON_PCB),1 (THERMISTOR_ON_BATT)"
    tree.end
    tree "FG_BATT_BATT_ID_CURR0"
      sgroup "FG_BATT_BATT_ID_CURR0 (at 0x41f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM                                     = "
    tree.end
    tree "FG_BATT_BATT_ID_CURR1"
      sgroup "FG_BATT_BATT_ID_CURR1 (at 0x41f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM                                     = "
    tree.end
    tree "FG_BATT_ESR_CUR"
      sgroup "FG_BATT_ESR_CUR (at 0x41f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG                                      = " "0 (ESR_MEAS_CUR_60MA),1 (ESR_MEAS_CUR_180MA),2 (ESR_MEAS_CUR_120MA),3 (ESR_MEAS_CUR_240MA)"
    tree.end
    tree "FG_BATT_ESR_MEAS_EN"
      sgroup "FG_BATT_ESR_MEAS_EN (at 0x41f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG                                      = " "0 (ESR_MEAS_DISABLE),1 (ESR_MEAS_ENABLE)"
    tree.end
    tree "FG_BATT_RBIAS_DIV"
      sgroup "FG_BATT_RBIAS_DIV (at 0x41f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL                                      = " "0 (RBIAS_REF_UNBUF),1 (RBIAS_REF_BUF)"
    tree.end
    tree "FG_BATT_BUGFIX_CFG"
      sgroup "FG_BATT_BUGFIX_CFG (at 0x41f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_FULL_FIX_EN                          = " "0 (SOC_FULL_FIX_DSBL),1 (SOC_FULL_FIX_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_CUTOFF_FIX_EN                        = " "0 (SOC_CUTOFF_FIX_DSBL),1 (SOC_CUTOFF_FIX_EN)"
    tree.end
  tree.end
tree.end
tree "FG_MEMIF"
  tree "FG_MEMIF"
    tree "FG_MEMIF_REVISION1"
      sgroup "FG_MEMIF_REVISION1 (at 0x4400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION2"
      sgroup "FG_MEMIF_REVISION2 (at 0x4401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION3"
      sgroup "FG_MEMIF_REVISION3 (at 0x4402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION4"
      sgroup "FG_MEMIF_REVISION4 (at 0x4403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FG_MEMIF_PERPH_TYPE"
      sgroup "FG_MEMIF_PERPH_TYPE (at 0x4404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_MEMIF_PERPH_SUBTYPE"
      sgroup "FG_MEMIF_PERPH_SUBTYPE (at 0x4405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_MEMIF_INT_RT_STS"
      sgroup "FG_MEMIF_INT_RT_STS (at 0x4410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_RT_STS                    = " "0 (DATA_RCVRY_SUG_FALSE),1 (DATA_RCVRY_SUG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_RT_STS                           = " "0 (IMA_EXCEPTION_FALSE),1 (IMA_EXCEPTION_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_RT_STS                            = " "0 (FG_MEM_ST0),1 (FG_MEM_ST1)"
    tree.end
    tree "FG_MEMIF_INT_SET_TYPE"
      sgroup "FG_MEMIF_INT_SET_TYPE (at 0x4411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_MEMIF_INT_POLARITY_HIGH"
      sgroup "FG_MEMIF_INT_POLARITY_HIGH (at 0x4412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEMIF_INT_POLARITY_LOW"
      sgroup "FG_MEMIF_INT_POLARITY_LOW (at 0x4413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEMIF_INT_LATCHED_CLR"
      sgroup "FG_MEMIF_INT_LATCHED_CLR (at 0x4414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_LATCHED_CLR           = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_LATCHED_CLR                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_LATCHED_CLR                   = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_EN_SET"
      sgroup "FG_MEMIF_INT_EN_SET (at 0x4415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_EN_SET                = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_EN_SET                       = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_EN_SET                        = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_EN_CLR"
      sgroup "FG_MEMIF_INT_EN_CLR (at 0x4416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_EN_CLR                = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_EN_CLR                       = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_EN_CLR                        = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_LATCHED_STS"
      sgroup "FG_MEMIF_INT_LATCHED_STS (at 0x4418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_LATCHED_STS           = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_LATCHED_STS                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_LATCHED_STS                   = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_PENDING_STS"
      sgroup "FG_MEMIF_INT_PENDING_STS (at 0x4419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_PENDING_STS           = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_PENDING_STS                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_PENDING_STS                   = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_MID_SEL"
      sgroup "FG_MEMIF_INT_MID_SEL (at 0x441a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_MEMIF_INT_PRIORITY"
      sgroup "FG_MEMIF_INT_PRIORITY (at 0x441b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_CFG"
      sgroup "FG_MEMIF_MEM_INTF_CFG (at 0x4450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_REQ                       = " "0 (RIF_MEM_ACCESS_REQ_FALSE),1 (RIF_MEM_ACCESS_REQ_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LOW_LATENCY_ACS_EN                       = " "0 (LOW_LATENCY_ACS_EN_FALSE),1 (LOW_LATENCY_ACS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IACS_SLCT                                = " "0 (CONVENTIONAL_ACS_MODE),1 (INTERLEAVE_ACS_MODE)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_CTL"
      sgroup "FG_MEMIF_MEM_INTF_CTL (at 0x4451)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (MEM_ACS_SINGLE),1 (MEM_ACS_BURST)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "FG_MEMIF_IMA_CFG"
      sgroup "FG_MEMIF_IMA_CFG (at 0x4452)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CFG_FGXCT_PRD                            = " "0 (SOC_COMPUTE_PRD),1 (FG_ACS_PRD)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_WR_FGXCT_PRD                          = " "0 (DISABLE_WR_FGXCT_PRD),1 (ENABLE_WR_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_RD_FGXCT_PRD                          = " "0 (DISABLE_RD_FGXCT_PRD),1 (ENABLE_RD_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STATIC_CLK_EN                            = " "0 (IACS_DYNAMIC_CLK_EN),1 (IACS_STATIC_CLK_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IACS_INTR_SRC_SLCT                       = " "0 (END_OF_TRANSACTION),1 (IACS_RDY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IACS_CLR                                 = " "0 (IACS_NORMAL_MODE),1 (IACS_CLEAR_MODE)"
    tree.end
    tree "FG_MEMIF_IMA_OPERATION_STS"
      sgroup "FG_MEMIF_IMA_OPERATION_STS (at 0x4454)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FGXCT_PRD                                = " "0 (FG_FREE_PRD),1 (FG_XCT_PERIOD)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_FGXCT_PRD_LOG                         = " "0 (INTERLEAVE_WR_FGFREE_PRD),1 (INTERLEAVE_WR_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RD_FGXCT_PRD_LOG                         = " "0 (INTERLEAVE_RD_FGFREE_PRD),1 (INTERLEAVE_RD_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IACS_CLK_REQ                             = " "0 (INTERLEAVE_ACS_CLK_REQ_IDLE),1 (INTERLEAVE_ACS_CLK_REQ_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IACS_INTR_STS                            = " "0 (IACS_INTR_IDLE),1 (IACS_INTR_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CACS_INTR_STS                            = " "0 (CACS_INTR_IDLE),1 (CACS_INTR_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IACS_RDY                                 = " "0 (INTERLEAVE_ACS_IN_PROGRESS),1 (INTERLEAVE_ACS_IDLE)"
    tree.end
    tree "FG_MEMIF_IMA_EXCEPTION_STS"
      sgroup "FG_MEMIF_IMA_EXCEPTION_STS (at 0x4455)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_SRC_ERR                             = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ADDR_RNG_ERR                             = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_BURST_WRAP                          = " "0 (NO_WRAP),1 (WRAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DATA_WR_ERR                              = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DATA_RD_ERR                              = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BE_BURSTWR_WARN                          = " "0 (NO_WARN),1 (WARN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   XCT_TYPE_ERR                             = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IACS_ERR                                 = " "0 (NO_ERR),1 (ERR)"
    tree.end
    tree "FG_MEMIF_IMA_HARDWARE_STS"
      sgroup "FG_MEMIF_IMA_HARDWARE_STS (at 0x4456)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_MSB_WR_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DATA_MSB_WR_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DATA_MSB_RD_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADDR_MSB_WR_TGL_RCV                      = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_MSB_WR_TGL_RCV                      = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_MSB_RD_TGL_RCV                      = " "0 (ST0),1 (ST1)"
    tree.end
    tree "FG_MEMIF_FG_BEAT_COUNT"
      sgroup "FG_MEMIF_FG_BEAT_COUNT (at 0x4457)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BEAT_CNT                                 = "
    tree.end
    tree "FG_MEMIF_IMA_ERR_STS"
      sgroup "FG_MEMIF_IMA_ERR_STS (at 0x445f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80445f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x445f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_STBL_ERR                            = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_ACS_ERR                               = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RD_ACS_ERR                               = " "0 (NO_ERR),1 (ERR)"
    tree.end
    tree "FG_MEMIF_IMA_BYTE_EN"
      sgroup "FG_MEMIF_IMA_BYTE_EN (at 0x4460)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BE3                                      = " "0 (BE3_DSBL),1 (BE3_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BE2                                      = " "0 (BE2_DSBL),1 (BE2_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BE1                                      = " "0 (BE1_DSBL),1 (BE1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BE0                                      = " "0 (BE0_DSBL),1 (BE0_EN)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_ADDR_LSB"
      sgroup "FG_MEMIF_MEM_INTF_ADDR_LSB (at 0x4461)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_ADDR_MSB"
      sgroup "FG_MEMIF_MEM_INTF_ADDR_MSB (at 0x4462)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA0"
      sgroup "FG_MEMIF_MEM_INTF_WR_DATA0 (at 0x4463)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA1"
      sgroup "FG_MEMIF_MEM_INTF_WR_DATA1 (at 0x4464)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA2"
      sgroup "FG_MEMIF_MEM_INTF_WR_DATA2 (at 0x4465)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA3"
      sgroup "FG_MEMIF_MEM_INTF_WR_DATA3 (at 0x4466)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA0"
      sgroup "FG_MEMIF_MEM_INTF_RD_DATA0 (at 0x4467)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA1"
      sgroup "FG_MEMIF_MEM_INTF_RD_DATA1 (at 0x4468)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA2"
      sgroup "FG_MEMIF_MEM_INTF_RD_DATA2 (at 0x4469)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA3"
      sgroup "FG_MEMIF_MEM_INTF_RD_DATA3 (at 0x446a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80446a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x446a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "FG_MEMIF_SEC_ACCESS"
      sgroup "FG_MEMIF_SEC_ACCESS (at 0x44d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL2"
      sgroup "FG_MEMIF_PERPH_RESET_CTL2 (at 0x44d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL3"
      sgroup "FG_MEMIF_PERPH_RESET_CTL3 (at 0x44da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL4"
      sgroup "FG_MEMIF_PERPH_RESET_CTL4 (at 0x44db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_TEST1"
      sgroup "FG_MEMIF_INT_TEST1 (at 0x44e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_MEMIF_INT_TEST_VAL"
      sgroup "FG_MEMIF_INT_TEST_VAL (at 0x44e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_RCVRY_SUG_INT_TEST_VAL              = " "0 (DATA_RCVRY_SUG_INT_TEST_VAL_FALSE),1 (DATA_RCVRY_SUG_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IMA_XCP_INT_TEST_VAL                     = " "0 (IMA_XCP_INT_TEST_VAL_FALSE),1 (FG_MEM_AVAIL_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_INT_TEST_VAL                      = " "0 (FG_MEM_INT_TEST_VAL_FALSE),1 (FG_MEM_AVAIL_INT_TEST_VAL_TRUE)"
    tree.end
    tree "FG_MEMIF_OTP_CFG1"
      sgroup "FG_MEMIF_OTP_CFG1 (at 0x44e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (VPP_SEL_DVDD),1 (VPP_SEL_VPP)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAM_DISABLE),1 (OTP_PROGRAM_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (OTP_TM0),1 (OTP_TM1),2 (OTP_TM2),3 (OTP_TM3)"
    tree.end
    tree "FG_MEMIF_OTP_CFG2"
      sgroup "FG_MEMIF_OTP_CFG2 (at 0x44e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
  tree.end
tree.end
tree "FG_SOC"
  tree "FG_SOC"
    tree "FG_SOC_PERPH_TYPE"
      sgroup "FG_SOC_PERPH_TYPE (at 0x4004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_SOC_PERPH_SUBTYPE"
      sgroup "FG_SOC_PERPH_SUBTYPE (at 0x4005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_SOC_FG_ALG_STS"
      sgroup "FG_SOC_FG_ALG_STS (at 0x4006)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0 (FG_NOT_READY),1 (FG_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BOOT_DONE                                = " "0 (FG_BOOT_NOT_DONE),1 (FG_BOOT_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_ITER_DONE                          = " "0 (FG_FIRST_ITER_NOT_DONE),1 (FG_FIRST_ITER_DONE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESTART_DONE                             = " "0 (FG_RESTART_NOT_DONE),1 (FG_RESTART_DONE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RESTART_IN_PROGRESS                      = " "0 (FG_RESTART_NOT_IN_PROGRESS),1 (FG_RESTART_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_EXP                                 = " "0 (FG_WDOG_NOT_EXPIRED),1 (FG_WDOG_EXPIRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CYCLE_STRETCHED                          = " "0 (FG_CYCLE_NOT_STRETCHED),1 (FG_CYCLE_STRETCHED)"
    tree.end
    tree "FG_SOC_FG_ALG_AUX_STS0"
      sgroup "FG_SOC_FG_ALG_AUX_STS0 (at 0x4007)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_BELOW_TERMINATION                      = " "0 (TERM_CURRENT_NOT_REACHED),1 (TERM_CURRENT_REACHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   V_REACHED_FLOAT_THRESHOLD                = " "0 (VBATT_FLOAT_NOT_REACHED),1 (VBATT_FLOAT_REACHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   I_CC_AVAILABLE                           = " "0 (I_CC_INACTIVE),1 (I_CC_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_PREDICTION_CHARGE                   = " "0 (BATT_MODEL_DISCHARGE),1 (BATT_MODEL_CHARGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PULSE_APPROVED                           = " "0 (PULSE_NOT_APPROVED),1 (PULSE_APPROVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ONCONNECT_OCV                            = " "0 (ONCONNECT_OCV_FALSE),1 (ONCONNECT_OCV_TRUE)"
    tree.end
    tree "FG_SOC_SLEEP_SHUTDOWN_STS"
      sgroup "FG_SOC_SLEEP_SHUTDOWN_STS (at 0x4008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_SLEEP_CC                              = " "0 (SLEEP_CC_NOT_REQUESTED),1 (SLEEP_CC_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FG_SLEEP_SYNC                            = " "0 (SLEEP_SYNC_NOT_REQUESTED),1 (SLEEP_SYNC_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SHUTDOWN_OR_SLEEP                        = " "0 (FG_AWAKE),1 (FG_IN_SHDN_OR_SLEEP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FG_SHUTDOWN_REQ                          = " "0 (SHUTDOWN_NOT_REQUESTED),1 (SHUTDOWN_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_SHUTDOWN_ALLOWED                      = " "0 (FG_NOT_IN_SHDN),1 (FG_SHDN_ACK)"
    tree.end
    tree "FG_SOC_FG_MONOTONIC_SOC"
      sgroup "FG_SOC_FG_MONOTONIC_SOC (at 0x4009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_SOC_FG_MONOTONIC_SOC_CP"
      sgroup "FG_SOC_FG_MONOTONIC_SOC_CP (at 0x400a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_SOC_INT_RT_STS"
      sgroup "FG_SOC_INT_RT_STS (at 0x4010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_SOC_INT_SET_TYPE"
      sgroup "FG_SOC_INT_SET_TYPE (at 0x4011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_SOC_INT_POLARITY_HIGH"
      sgroup "FG_SOC_INT_POLARITY_HIGH (at 0x4012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_SOC_INT_POLARITY_LOW"
      sgroup "FG_SOC_INT_POLARITY_LOW (at 0x4013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_SOC_INT_LATCHED_CLR"
      sgroup "FG_SOC_INT_LATCHED_CLR (at 0x4014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_CLR                 = " "0, 1"
    tree.end
    tree "FG_SOC_INT_EN_SET"
      sgroup "FG_SOC_INT_EN_SET (at 0x4015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_LATCHED_SET               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_SET           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_SET                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_SET                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_SET                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_SET                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_SOC_INT_EN_CLR"
      sgroup "FG_SOC_INT_EN_CLR (at 0x4016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_EN_CLR                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_EN_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_EN_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_SOC_INT_LATCHED_STS"
      sgroup "FG_SOC_INT_LATCHED_STS (at 0x4018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_STS           = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_SOC_INT_PENDING_STS"
      sgroup "FG_SOC_INT_PENDING_STS (at 0x4019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_PENDING_STS           = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_SOC_INT_MID_SEL"
      sgroup "FG_SOC_INT_MID_SEL (at 0x401a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_SOC_INT_PRIORITY"
      sgroup "FG_SOC_INT_PRIORITY (at 0x401b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_SOC_BOOT_MOD"
      sgroup "FG_SOC_BOOT_MOD (at 0x4050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PREVENT_OTP_SYS_RELOAD                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PREVENT_OTP_PROFILE_RELOAD               = " "0 (DO_NOT_PREVENT_OTP_PROFILE_RELOAD),1 (PREVENT_OTP_PROFILE_RELOAD)"
    tree.end
    tree "FG_SOC_RESTART"
      sgroup "FG_SOC_RESTART (at 0x4051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REDO_BATID_DURING_FIRST_EST              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RERUN_FIRST_EST                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RELOAD_PROFILE                           = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RELOAD_SYS                               = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GO                                       = " "0 (DO_NOT_EXECUTE_SEQUENCE),1 (EXECUTE_SEQUENCE)"
    tree.end
    tree "FG_SOC_FG_WDOG_EXP"
      sgroup "FG_SOC_FG_WDOG_EXP (at 0x4052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "FG_SOC_STS_CLR"
      sgroup "FG_SOC_STS_CLR (at 0x4053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CYCLE_STRETCH_CLR                        = " "0 (NORMAL),1 (CLEAR)"
    tree.end
    tree "FG_SOC_SPARE_FG"
      sgroup "FG_SOC_SPARE_FG (at 0x4054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ALG_ST"
      sgroup "FG_SOC_ALG_ST (at 0x40cf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040cf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40cf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CMP                                      = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ST_MAC                                   = "
    tree.end
    tree "FG_SOC_SEC_ACCESS"
      sgroup "FG_SOC_SEC_ACCESS (at 0x40d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL2"
      sgroup "FG_SOC_PERPH_RESET_CTL2 (at 0x40d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL3"
      sgroup "FG_SOC_PERPH_RESET_CTL3 (at 0x40da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL4"
      sgroup "FG_SOC_PERPH_RESET_CTL4 (at 0x40db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_SOC_INT_TEST1"
      sgroup "FG_SOC_INT_TEST1 (at 0x40e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_SOC_INT_TEST_VAL"
      sgroup "FG_SOC_INT_TEST_VAL (at 0x40e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPDATE_SOC_INT_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_TEST_VAL              = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_TEST_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_TEST_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_SOC_ADC_TST1"
      sgroup "FG_SOC_ADC_TST1 (at 0x40e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST2"
      sgroup "FG_SOC_ADC_TST2 (at 0x40e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST3"
      sgroup "FG_SOC_ADC_TST3 (at 0x40e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST4"
      sgroup "FG_SOC_ADC_TST4 (at 0x40e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST5"
      sgroup "FG_SOC_ADC_TST5 (at 0x40e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST6"
      sgroup "FG_SOC_ADC_TST6 (at 0x40e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_VADC_DATA0"
      sgroup "FG_SOC_VADC_DATA0 (at 0x40e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BYTE_7_0                                 = "
    tree.end
    tree "FG_SOC_BCL_TST0"
      sgroup "FG_SOC_BCL_TST0 (at 0x40e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FORCE_BCL_MODE                           = " "0, 1, 2, 3"
    tree.end
    tree "FG_SOC_DBG_CFG"
      sgroup "FG_SOC_DBG_CFG (at 0x40ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CFG7_3                                   = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG2                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG1_0                                   = " "0, 1, 2, 3"
    tree.end
    tree "FG_SOC_ALG_STS_CMP"
      sgroup "FG_SOC_ALG_STS_CMP (at 0x40eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ALG_ST_TRACKER                           = "
    tree.end
    tree "FG_SOC_TEST_DT"
      sgroup "FG_SOC_TEST_DT (at 0x40ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_TRIM_COPY_DONE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ADC_REAL_CONV                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_CONV_I_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_CONV_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ADC_V_SOURCE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_CONV_V_USE_SOURCE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CONV_V                               = " "0, 1"
    tree.end
    tree "FG_SOC_TEST_CLK_MANAGER"
      sgroup "FG_SOC_TEST_CLK_MANAGER (at 0x40ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MUX_EN                                   = " "0 (MUX_DISABLED),1 (MUX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   CTRL                                     = " "0 (NO_CLOCK_PROVIDED),1 (USE_STANDBY_CLOCK),2 (USE_MAIN_OSC),3 (INVALID_SELECTION)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   MUX_BITS                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_SOC_TEST_MUX0"
      sgroup "FG_SOC_TEST_MUX0 (at 0x40ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MUX_EN                                   = " "0 (MUX_DISABLED),1 (MUX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_SYS_SLEEP                          = " "0 (FORCE0),1 (FORCE1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_ULTRA_LOW_PWR                      = " "0 (FORCE0),1 (FORCE1)"
    tree.end
    tree "FG_SOC_TRIM_NUM"
      sgroup "FG_SOC_TRIM_NUM (at 0x40f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_SOC_FG_PBS_TRIG"
      sgroup "FG_SOC_FG_PBS_TRIG (at 0x40f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_SEL_EN                             = " "0 (ENABLE_DTEST_FOR_PBS_DISABLE),1 (ENABLE_DTEST_FOR_PBS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   INV                                      = " "0 (INVERT_DTEST_DISABLE),1 (INVERT_DTEST_ENABLE)"
    tree.end
    tree "FG_SOC_FG_PBS_TRIG_MUX"
      sgroup "FG_SOC_FG_PBS_TRIG_MUX (at 0x40f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                                      = "
    tree.end
    tree "FG_SOC_FG_RESET"
      sgroup "FG_SOC_FG_RESET (at 0x40f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (FG_NOT_IN_RESET),1 (FG_IN_RESET)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPE_SEL                                 = " "0 (HYBRID_DVDD_RB_RAW),1 (HYBRID_DVDD_RB)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_CTRL_RST                             = " "0 (CLK_CTRL_NOT_IN_RESET),1 (CLK_CTRL_IN_RESET)"
    tree.end
    tree "FG_SOC_FG_CYA_CFG"
      sgroup "FG_SOC_FG_CYA_CFG (at 0x40f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_WDOG_EN                               = " "0 (FG_WDOG_DISABLED),1 (FG_WDOG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LCSMB_TRIM                               = " "0 (DO_NOT_USE_ADC_LOW_CURRENT_MODE),1 (USE_ADC_LOW_CURRENT_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   I_ADC_SRC_MUX_SEL                        = " "0 (I_ADC_SRC_FROM_FG),1 (I_ADC_SRC_FROM_FG_CYA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   I_ADC_SRC_SEL                            = " "0 (I_ADC_FROM_BATFET),1 (I_ADC_FROM_ISENSE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   V_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   V_ADC_CMP_POL_TRIM                       = " "0 (V_ADC_POS_IS_POS),1 (V_ADC_POS_IS_NEG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I_ADC_CMP_POL_TRIM                       = " "0 (I_ADC_DISCH_POS),1 (I_ADC_DISCH_NEG)"
    tree.end
    tree "FG_SOC_LOW_PWR_CFG"
      sgroup "FG_SOC_LOW_PWR_CFG (at 0x40f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CC_SLEEP_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_SLEEP_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SYNC_SLEEP_CFG                           = " "0 (ACTIVE2_SLEEP2),1 (ACTIVE2_SLEEP4),2 (ACTIVE2_SLEEP8),3 (ACTIVE2_SLEEP14)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC_SLEEP_REGEN_ESR_EN                  = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_SLEEP_BCL1_EN                       = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_SLEEP_THRSH2_EN                     = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LO_FRQ_CLKSWITCH_EN                      = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_SOC_BCL_V_GAIN_BATT_TRIM"
      sgroup "FG_SOC_BCL_V_GAIN_BATT_TRIM (at 0x40f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_GAIN_RSENSE_TRIM"
      sgroup "FG_SOC_BCL_I_GAIN_RSENSE_TRIM (at 0x40f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_OFFSET_RSENSE_TRIM"
      sgroup "FG_SOC_BCL_I_OFFSET_RSENSE_TRIM (at 0x40f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_GAIN_BATFET_TRIM"
      sgroup "FG_SOC_BCL_I_GAIN_BATFET_TRIM (at 0x40f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_OFFSET_BATFET_TRIM"
      sgroup "FG_SOC_BCL_I_OFFSET_BATFET_TRIM (at 0x40fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
  tree.end
tree.end
tree "FLASH1"
  tree "FLASH1"
    tree "FLASH1_REVISION1"
      sgroup "FLASH1_REVISION1 (at 0x1d300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION2"
      sgroup "FLASH1_REVISION2 (at 0x1d301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FLASH1_REVISION3"
      sgroup "FLASH1_REVISION3 (at 0x1d302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION4"
      sgroup "FLASH1_REVISION4 (at 0x1d303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FLASH1_PERPH_TYPE"
      sgroup "FLASH1_PERPH_TYPE (at 0x1d304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FLASH1_PERPH_SUBTYPE"
      sgroup "FLASH1_PERPH_SUBTYPE (at 0x1d305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FLASH1_LED_FAULT_STATUS"
      sgroup "FLASH1_LED_FAULT_STATUS (at 0x1d308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OK_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERMAL_DERATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED2_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_SHORT_FAULT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_SHORT_FAULT                         = " "0, 1"
    tree.end
    tree "FLASH1_LED1_IRAMP_STATUS"
      sgroup "FLASH1_LED1_IRAMP_STATUS (at 0x1d309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_LED2_IRAMP_STATUS"
      sgroup "FLASH1_LED2_IRAMP_STATUS (at 0x1d30a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_LED1_MASK_RAMP_STATUS"
      sgroup "FLASH1_LED1_MASK_RAMP_STATUS (at 0x1d30b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_MASK_CLIP_CURRENT                   = "
    tree.end
    tree "FLASH1_LED2_MASK_RAMP_STATUS"
      sgroup "FLASH1_LED2_MASK_RAMP_STATUS (at 0x1d30c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_MASK_CLIP_CURRENT                   = "
    tree.end
    tree "FLASH1_INT_RT_STS"
      sgroup "FLASH1_INT_RT_STS (at 0x1d310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_RT_STS                  = " "0, 1"
    tree.end
    tree "FLASH1_INT_SET_TYPE"
      sgroup "FLASH1_INT_SET_TYPE (at 0x1d311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TYPE                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FLASH1_INT_POLARITY_HIGH"
      sgroup "FLASH1_INT_POLARITY_HIGH (at 0x1d312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FLASH1_INT_POLARITY_LOW"
      sgroup "FLASH1_INT_POLARITY_LOW (at 0x1d313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FLASH1_INT_LATCHED_CLR"
      sgroup "FLASH1_INT_LATCHED_CLR (at 0x1d314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "FLASH1_INT_EN_SET"
      sgroup "FLASH1_INT_EN_SET (at 0x1d315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FLASH1_INT_EN_CLR"
      sgroup "FLASH1_INT_EN_CLR (at 0x1d316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FLASH1_INT_LATCHED_STS"
      sgroup "FLASH1_INT_LATCHED_STS (at 0x1d318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FLASH1_INT_PENDING_STS"
      sgroup "FLASH1_INT_PENDING_STS (at 0x1d319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FLASH1_INT_MID_SEL"
      sgroup "FLASH1_INT_MID_SEL (at 0x1d31a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FLASH1_INT_PRIORITY"
      sgroup "FLASH1_INT_PRIORITY (at 0x1d31b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FLASH1_FLASH_SAFETY_TIMER"
      sgroup "FLASH1_FLASH_SAFETY_TIMER (at 0x1d340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   FLASH_TIMER_DURATION                     = "
    tree.end
    tree "FLASH1_MAX_FLSH_CURRENT"
      sgroup "FLASH1_MAX_FLSH_CURRENT (at 0x1d341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAX_LED_CURRENT                          = "
    tree.end
    tree "FLASH1_LED1_CURRENT_PRGM"
      sgroup "FLASH1_LED1_CURRENT_PRGM (at 0x1d342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_LED2_CURRENT_PRGM"
      sgroup "FLASH1_LED2_CURRENT_PRGM (at 0x1d343)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_MASK_CLAMP_CURRENT"
      sgroup "FLASH1_MASK_CLAMP_CURRENT (at 0x1d344)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MASK_CURRENT                             = "
    tree.end
    tree "FLASH1_ENABLE_CONTROL"
      sgroup "FLASH1_ENABLE_CONTROL (at 0x1d346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_ENABLE                            = " "0 (MOD_DIS),1 (MOD_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED1_DRVR_SEL                            = " "0 (TORCH_EN),1 (FLASH_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED2_DRVR_SEL                            = " "0 (TORCH_EN),1 (FLASH_EN)"
    tree.end
    tree "FLASH1_LED_STROBE_CONTROL"
      sgroup "FLASH1_LED_STROBE_CONTROL (at 0x1d347)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LED1_OUTPUT                           = " "0 (LED1_DIS),1 (LED1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_LED2_OUTPUT                           = " "0 (LED2_DIS),1 (LED2_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0 (STROBE_SW),1 (STROBE_HW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0 (ACTIVE_LOW),1 (ACTIVE_HIGH)"
    tree.end
    tree "FLASH1_LED_TMR_CONTROL"
      sgroup "FLASH1_LED_TMR_CONTROL (at 0x1d348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIMER1_SEL                               = " "0 (LED1_TIMER_FLASH),1 (LED1_TIMER_WTCHDG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER2_SEL                               = " "0 (LED2_TIMER_FLASH),1 (LED2_TIMER_WTCHDG)"
    tree.end
    tree "FLASH1_WATCHDOG_TIMER"
      sgroup "FLASH1_WATCHDOG_TIMER (at 0x1d349)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   WATCHDOG_TIMER_DURATION                  = "
    tree.end
    tree "FLASH1_FLASH_HEADRM_PRGM"
      sgroup "FLASH1_FLASH_HEADRM_PRGM (at 0x1d34a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLSH_DRVR_HEADROOM                       = " "0 (HEADRM_250MV),1 (HEADRM_300MV),2 (HEADRM_400MV),3 (HEADRM_500MV)"
    tree.end
    tree "FLASH1_STARTUP_DELAY"
      sgroup "FLASH1_STARTUP_DELAY (at 0x1d34b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STARTUP_DELAY                            = " "0 (STRTUP_DLY_10US),1 (STRTUP_DLY_32US),2 (STRTUP_DLY_64US),3 (STRTUP_DLY_128US)"
    tree.end
    tree "FLASH1_MASK_ENABLE"
      sgroup "FLASH1_MASK_ENABLE (at 0x1d34c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MASK3                                 = " "0 (MASK3_DIS),1 (MASK3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_MASK2                                 = " "0 (MASK2_DIS),1 (MASK2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_MASK1                                 = " "0 (VPH_DROOP_DIS),1 (VPH_DROOP_EN)"
    tree.end
    tree "FLASH1_LED1_FINE_CURRENT_PRGM"
      sgroup "FLASH1_LED1_FINE_CURRENT_PRGM (at 0x1d34d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_LED2_FINE_CURRENT_PRGM"
      sgroup "FLASH1_LED2_FINE_CURRENT_PRGM (at 0x1d34e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_VREG_OK_FORCE"
      sgroup "FLASH1_VREG_OK_FORCE (at 0x1d34f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FORCE_VREG_OK                         = " "0 (VREGOK_0),1 (VREGOK_1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HW_VREG_OK                        = " "0 (VREGOK_SW),1 (VREGOK_HW)"
    tree.end
    tree "FLASH1_MASK_CONFIG"
      sgroup "FLASH1_MASK_CONFIG (at 0x1d350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK3_POLARITY                           = " "0 (MASK3_ACTIVE_LOW),1 (MASK3_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MASK2_POLARITY                           = " "0 (MASK2_ACTIVE_LOW),1 (MASK2_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK1_POLARITY                           = " "0 (MASK1_ACTIVE_LOW),1 (MASK1_ACTIVE_HIGH)"
    tree.end
    tree "FLASH1_FAULT_DETECT"
      sgroup "FLASH1_FAULT_DETECT (at 0x1d351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SELF_CHECK                            = " "0 (SELF_CHECK_DIS),1 (SELF_CHECK_EN)"
    tree.end
    tree "FLASH1_THERMAL_DERATE"
      sgroup "FLASH1_THERMAL_DERATE (at 0x1d352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_THERMAL_DERATE                        = " "0 (THERM_DERATE_DIS),1 (THERM_DERATE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   DERATE_RATE                              = " "0 (RATE_1_PERCENT),1 (RATE_1P25_PERCENT),2 (RATE_2_PERCENT),3 (RATE_2P5_PERCENT),4 (RATE_5_PERCENT),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DERATE_THRESHOLD                         = " "0 (THRESHOLD_95C),1 (THRESHOLD_105C),2 (THRESHOLD_115C),3 (THRESHOLD_125C),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "FLASH1_PWM_DIMMING"
      sgroup "FLASH1_PWM_DIMMING (at 0x1d353)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_DIMMING                           = " "0 (PWM_DIM_DIS),1 (PWM_DIM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FULL_SCALE_CURRENT                   = " "0 (PWMDIMMING_12P5MA),1 (PWMDIMMING_25MA),2 (PWMDIMMING_37P5MA),3 (PWMDIMMING_50MA),4 (PWMDIMMING_62P5MA),5 (PWMDIMMING_75MA),6 (PWMDIMMING_87P5MA),7 (PWMDIMMING_100MA)"
    tree.end
    tree "FLASH1_LED_CURRENT_RAMP"
      sgroup "FLASH1_LED_CURRENT_RAMP (at 0x1d354)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_RAMP                                  = " "0 (RAMP_DIS),1 (RAMP_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_UP_STEP                             = " "0 (RAMP_UP_STEP_0P2US),1 (RAMP_UP_STEP_0P4US),2 (RAMP_UP_STEP_0P8US),3 (RAMP_UP_STEP_1P6US),4 (RAMP_UP_STEP_3P3US),5 (RAMP_UP_STEP_6P7US),6 (RAMP_UP_STEP_13P5US),7 (RAMP_UP_STEP_27US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_DN_STEP                             = " "0 (RAMP_DN_STEP_0P2US),1 (RAMP_DN_STEP_0P4US),2 (RAMP_DN_STEP_0P8US),3 (RAMP_DN_STEP_1P6US),4 (RAMP_DN_STEP_3P3US),5 (RAMP_DN_STEP_6P7US),6 (RAMP_DN_STEP_13P5US),7 (RAMP_DN_STEP_27US)"
    tree.end
    tree "FLASH1_ALT_RAMP_DN"
      sgroup "FLASH1_ALT_RAMP_DN (at 0x1d355)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ALTERNATE_RAMP_DN                        = " "0 (ALT_RMP_DWN_0P2US),1 (ALT_RMP_DWN_0P4US),2 (ALT_RMP_DWN_0P8US),3 (ALT_RMP_DWN_1P6US)"
    tree.end
    tree "FLASH1_WATCHDOG_PET"
      sgroup "FLASH1_WATCHDOG_PET (at 0x1d356)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PET_WATCHDOG                             = " "0, 1"
    tree.end
    tree "FLASH1_STROBE_DEBOUNCE"
      sgroup "FLASH1_STROBE_DEBOUNCE (at 0x1d357)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_STROBE                     = " "0 (STROBE_DEBOUNCE_0US),1 (STROBE_DEBOUNCE_10US),2 (STROBE_DEBOUNCE_32US),3 (STROBE_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_MASK_DEBOUNCE"
      sgroup "FLASH1_MASK_DEBOUNCE (at 0x1d358)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_MASK1                      = " "0 (MASK1_DEBOUNCE_0US),1 (MASK1_DEBOUNCE_10US),2 (MASK1_DEBOUNCE_32US),3 (MASK1_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_OTHER_MASKS                = " "0 (OTHER_MASK_DEBOUNCE_0US),1 (OTHER_MASK_DEBOUNCE_10US),2 (OTHER_MASK_DEBOUNCE_32US),3 (OTHER_MASK_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_FAULT_DEBOUNCE"
      sgroup "FLASH1_FAULT_DEBOUNCE (at 0x1d359)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_LED1_OPEN                  = " "0 (LED1_OPEN_DEBOUNCE_0US),1 (LED1_OPEN_DEBOUNCE_10US),2 (LED1_OPEN_DEBOUNCE_32US),3 (LED1_OPEN_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEBOUNCE_TIME_LED2_OPEN                  = " "0 (LED2_OPEN_DEBOUNCE_0US),1 (LED2_OPEN_DEBOUNCE_10US),2 (LED2_OPEN_DEBOUNCE_32US),3 (LED2_OPEN_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEBOUNCE_TIME_LED1_SHORT                 = " "0 (LED1_SHORT_DEBOUNCE_0US),1 (LED1_SHORT_DEBOUNCE_10US),2 (LED1_SHORT_DEBOUNCE_32US),3 (LED1_SHORT_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_LED2_SHORT                 = " "0 (LED2_SHORT_DEBOUNCE_0US),1 (LED2_SHORT_DEBOUNCE_10US),2 (LED2_SHORT_DEBOUNCE_32US),3 (LED2_SHORT_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_VPH_PWR_DROOP"
      sgroup "FLASH1_VPH_PWR_DROOP (at 0x1d35a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VPH_PWR_DROOP                         = " "0 (VPH_DROOP_DIS),1 (VPHDROOP_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   VPH_PWR_DROOP_THRESHOLD                  = " "0 (VDIP_THRES_2P5V),1 (VDIP_THRES_2P6V),2 (VDIP_THRES_2P7V),3 (VDIP_THRES_2P8V),4 (VDIP_THRES_2P9V),5 (VDIP_THRES_3V),6 (VDIP_THRES_3P1V),7 (VDIP_THRES_3P2V)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_VPH_PWR_DROOP              = " "0 (VPH_DROOP_DEBOUNCE_0US),1 (VPH_DROOP_DEBOUNCE_10US),2 (VPH_DROOP_DEBOUNCE_32US),3 (VPH_DROOP_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_MASK_RAMP_CTRL"
      sgroup "FLASH1_MASK_RAMP_CTRL (at 0x1d35b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK_RAMP_CTRL                           = " "0 (MASK_RAMP_DIS),1 (MASK_RAMP_EN)"
    tree.end
    tree "FLASH1_LED1_HDRM_SNS_CTRL"
      sgroup "FLASH1_LED1_HDRM_SNS_CTRL (at 0x1d35c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_HDRM_SNS_EN                         = " "0 (LED1_HR_SNS_DIS),1 (LED1_HR_SNS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_GAIN_CORRECTION                     = " "0 (LED1_GAIN_CORR_HW),1 (LED1_GAIN_CORR_SW)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED1_HDRM_SNS_THRESHOLD                  = " "0 (LED1_HR_SNS_THRES_700MV),1 (LED1_HR_SNS_THRES_1000MV),2 (reserved),3 (reserved)"
    tree.end
    tree "FLASH1_LED2_HDRM_SNS_CTRL"
      sgroup "FLASH1_LED2_HDRM_SNS_CTRL (at 0x1d35d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_HDRM_SNS_EN                         = " "0 (LED2_HR_SNS_DIS),1 (LED2_HR_SNS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED2_GAIN_CORRECTION                     = " "0 (LED2_GAIN_CORR_HW),1 (LED2_GAIN_CORR_SW)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED2_HDRM_SNS_THRESHOLD                  = " "0 (LED2_HR_SNS_THRES_700MV),1 (LED2_HR_SNS_THRES_1000MV),2 (reserved),3 (reserved)"
    tree.end
    tree "FLASH1_SEC_ACCESS"
      sgroup "FLASH1_SEC_ACCESS (at 0x1d3d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FLASH1_PERPH_RESET_CTL2"
      sgroup "FLASH1_PERPH_RESET_CTL2 (at 0x1d3d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL3"
      sgroup "FLASH1_PERPH_RESET_CTL3 (at 0x1d3da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL4"
      sgroup "FLASH1_PERPH_RESET_CTL4 (at 0x1d3db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "FLASH1_INT_TEST1"
      sgroup "FLASH1_INT_TEST1 (at 0x1d3e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "FLASH1_INT_TEST_VAL"
      sgroup "FLASH1_INT_TEST_VAL (at 0x1d3e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TEST_VAL                = " "0, 1"
    tree.end
    tree "FLASH1_TEST1"
      sgroup "FLASH1_TEST1 (at 0x1d3e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "FLASH1_TEST2"
      sgroup "FLASH1_TEST2 (at 0x1d3e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FLSH_ATEST_CTRL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_TEST3"
      sgroup "FLASH1_TEST3 (at 0x1d3e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_WDOG_TIMER                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_SFTY_TIMER                            = " "0, 1"
    tree.end
    tree "FLASH1_TEST4"
      sgroup "FLASH1_TEST4 (at 0x1d3e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKRATE_TEST                             = " "0, 1"
    tree.end
    tree "FLASH1_TEST5"
      sgroup "FLASH1_TEST5 (at 0x1d3e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED1_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TEST6"
      sgroup "FLASH1_TEST6 (at 0x1d3e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED2_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TRIM_NUM"
      sgroup "FLASH1_TRIM_NUM (at 0x1d3f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "FLASH1_TRIM1"
      sgroup "FLASH1_TRIM1 (at 0x1d3f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM2"
      sgroup "FLASH1_TRIM2 (at 0x1d3f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VREG                      = "
    tree.end
    tree "FLASH1_TRIM3"
      sgroup "FLASH1_TRIM3 (at 0x1d3f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM4"
      sgroup "FLASH1_TRIM4 (at 0x1d3f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VREG                      = "
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO1_DIG_IN_DTEST_SEL"
      sgroup "GPIO1_DIG_IN_DTEST_SEL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO1_DIG_OUT_SOURCE_CTL (at 0xc044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_OUT_DRV_CTL"
      sgroup "GPIO1_DIG_OUT_DRV_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_ANA_PASS_THRU_SEL"
      sgroup "GPIO1_ANA_PASS_THRU_SEL (at 0xc04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO2_DIG_IN_DTEST_SEL"
      sgroup "GPIO2_DIG_IN_DTEST_SEL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO2_DIG_OUT_SOURCE_CTL (at 0xc144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_OUT_DRV_CTL"
      sgroup "GPIO2_DIG_OUT_DRV_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_ANA_PASS_THRU_SEL"
      sgroup "GPIO2_ANA_PASS_THRU_SEL (at 0xc14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "HAPTICS"
  tree "HAPTICS"
    tree "HAPTICS_REVISION1"
      sgroup "HAPTICS_REVISION1 (at 0x1c000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION2"
      sgroup "HAPTICS_REVISION2 (at 0x1c001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "HAPTICS_REVISION3"
      sgroup "HAPTICS_REVISION3 (at 0x1c002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION4"
      sgroup "HAPTICS_REVISION4 (at 0x1c003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "HAPTICS_PERPH_TYPE"
      sgroup "HAPTICS_PERPH_TYPE (at 0x1c004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "HAPTICS_PERPH_SUBTYPE"
      sgroup "HAPTICS_PERPH_SUBTYPE (at 0x1c005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "HAPTICS_STATUS_1"
      sgroup "HAPTICS_STATUS_1 (at 0x1c00a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_STS                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AUTO_RES_ERROR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SC_FLAG                                  = " "0 (NO_SC),1 (SC_DET)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OC_FLAG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BUSY                                     = " "0 (IDLE),1 (BUSY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PLAY_STS                                 = " "0, 1"
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_LO"
      sgroup "HAPTICS_LRA_AUTO_RES_LO (at 0x1c00b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_HI"
      sgroup "HAPTICS_LRA_AUTO_RES_HI (at 0x1c00c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_INT_RT_STS"
      sgroup "HAPTICS_INT_RT_STS (at 0x1c010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_RT_STS                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "HAPTICS_INT_SET_TYPE"
      sgroup "HAPTICS_INT_SET_TYPE (at 0x1c011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_SET_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "HAPTICS_INT_POLARITY_HIGH"
      sgroup "HAPTICS_INT_POLARITY_HIGH (at 0x1c012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_HIGH                   = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_POLARITY_LOW"
      sgroup "HAPTICS_INT_POLARITY_LOW (at 0x1c013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_LOW                    = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_CLR"
      sgroup "HAPTICS_INT_LATCHED_CLR (at 0x1c014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_SET"
      sgroup "HAPTICS_INT_EN_SET (at 0x1c015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_SET                          = " "0 (reserved),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_SET                            = " "0 (reserved),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_CLR"
      sgroup "HAPTICS_INT_EN_CLR (at 0x1c016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_CLR                          = " "0 (reserved),1 (INT_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_CLR                            = " "0 (reserved),1 (INT_DISABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_STS"
      sgroup "HAPTICS_INT_LATCHED_STS (at 0x1c018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "HAPTICS_INT_PENDING_STS"
      sgroup "HAPTICS_INT_PENDING_STS (at 0x1c019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "HAPTICS_INT_MID_SEL"
      sgroup "HAPTICS_INT_MID_SEL (at 0x1c01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "HAPTICS_INT_PRIORITY"
      sgroup "HAPTICS_INT_PRIORITY (at 0x1c01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "HAPTICS_EN_CTL1"
      sgroup "HAPTICS_EN_CTL1 (at 0x1c046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HAPTICS_EN                               = " "0 (HAPTICS_DIS),1 (HAPTICS_EN)"
    tree.end
    tree "HAPTICS_EN_CTL2"
      sgroup "HAPTICS_EN_CTL2 (at 0x1c048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_OTST2_EN                          = " "0 (DERATE_OTST2_DIS),1 (DERATE_OTST2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_HIGH_IBAT_EN                      = " "0 (DERATE_HIGH_IBAT_DIS),1 (DERATE_HIGH_IBAT_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DERATE_HIGH_TEMP_EN                      = " "0 (DERATE_HIGH_TEMP_DIS),1 (DERATE_HIGH_TEMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DERATE_LOW_VBAT_EN                       = " "0 (DERATE_LOW_VBAT_DIS),1 (DERATE_LOW_VBAT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BRAKE_EN                                 = " "0 (BRAKING_DIS),1 (BRAKING_EN)"
    tree.end
    tree "HAPTICS_EN_CTL3"
      sgroup "HAPTICS_EN_CTL3 (at 0x1c04a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HBRIDGE_EN                               = " "0 (HIGH_Z),1 (HBRIDGE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PWM_SIGNAL_EN                            = " "0 (PWM_ZERO),1 (PWM_SIGNAL_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIM_EN                                  = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILIM_CC_EN                               = " "0 (CC_EN),1 (CC_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUTO_RES_RBIAS_EN                        = " "0 (RBIAS_DIS),1 (RBIAS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_EN                                   = " "0 (DAC_DIS),1 (DAC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_HYST_EN                               = " "0 (ZX_HYST_DIS),1 (ZX_HYST_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_CTL_EN                               = " "0 (PWM_DIS),1 (PWM_CTL_EN)"
    tree.end
    tree "HAPTICS_CFG1"
      sgroup "HAPTICS_CFG1 (at 0x1c04c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ACTUATOR_TYPE                            = " "0 (LRA),1 (ERM)"
    tree.end
    tree "HAPTICS_CFG2"
      sgroup "HAPTICS_CFG2 (at 0x1c04d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LRA_RES_TYPE                             = " "0 (SINUSOID),1 (SQUARE)"
    tree.end
    tree "HAPTICS_SEL"
      sgroup "HAPTICS_SEL (at 0x1c04e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   WF_SOURCE                                = " "0 (VMAX),1 (BUFFER),2 (AUDIO),3 (EXT_PWM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER                                  = " "0 (HAPTICS_PLAY),1 (LINE_IN)"
    tree.end
    tree "HAPTICS_AUTO_RES_CFG"
      sgroup "HAPTICS_AUTO_RES_CFG (at 0x1c04f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   LRA_AUTO_RES_MODE                        = " "0 (NO_AUTO_RES),1 (ZXD),2 (QWD),3 (MAX_QWD),4 (ZXD_EOP),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LRA_HIGH_Z                               = " "0 (NO_HIGHZ),1 (HIGHZ_OPT1),2 (HIGHZ_OPT2),3 (HIGHZ_OPT3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LRA_RES_CALIB                            = " "0 (FOUR_PERIODS),1 (EIGHT_PERIODS),2 (SIXTEEN_PERIODS),3 (THIRTYTWO_PERIODS)"
    tree.end
    tree "HAPTICS_SLEW_CFG"
      sgroup "HAPTICS_SLEW_CFG (at 0x1c050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEW_RATE                                = " "0 (SLEW_6NS),1 (SLEW_16NS)"
    tree.end
    tree "HAPTICS_VMAX_CFG"
      sgroup "HAPTICS_VMAX_CFG (at 0x1c051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VMAX                                     = "
    tree.end
    tree "HAPTICS_ILIM_CFG"
      sgroup "HAPTICS_ILIM_CFG (at 0x1c052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_SEL                                 = " "0 (ILIM_400MA),1 (ILIM_800MA)"
    tree.end
    tree "HAPTICS_SC_DEB_CFG"
      sgroup "HAPTICS_SC_DEB_CFG (at 0x1c053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SC_DEB                                   = " "0 (NO_DEB),1 (DEB_8CLK),2 (DEB_16CLK),3 (DEB_32CLK),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "HAPTICS_RATE_CFG1"
      sgroup "HAPTICS_RATE_CFG1 (at 0x1c054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RATE_7_0                                 = "
    tree.end
    tree "HAPTICS_RATE_CFG2"
      sgroup "HAPTICS_RATE_CFG2 (at 0x1c055)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RATE_11_8                                = "
    tree.end
    tree "HAPTICS_INTERNAL_PWM"
      sgroup "HAPTICS_INTERNAL_PWM (at 0x1c056)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (PWM_253KHZ),1 (PWM_505KHZ),2 (PWM_739KHZ),3 (PWM_1076KHZ)"
    tree.end
    tree "HAPTICS_EXTERNAL_PWM"
      sgroup "HAPTICS_EXTERNAL_PWM (at 0x1c057)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (EXT_PWM_25KHZ),1 (EXT_PWM_50KHZ),2 (EXT_PWM_75KHZ),3 (EXT_PWM_100KHZ)"
    tree.end
    tree "HAPTICS_PWM"
      sgroup "HAPTICS_PWM (at 0x1c058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CAP_SEL                                  = " "0 (PWM_CAP_26PF),1 (PWM_CAP_13PF),2 (PWM_CAP_8P7PF),3 (PWM_CAP_6P5PF)"
    tree.end
    tree "HAPTICS_SC_CLR"
      sgroup "HAPTICS_SC_CLR (at 0x1c059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CLR                                   = " "0 (SC_DIS),1 (SC_CLR)"
    tree.end
    tree "HAPTICS_BRAKE"
      sgroup "HAPTICS_BRAKE (at 0x1c05c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c05c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   PATTERN4                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PATTERN3                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PATTERN2                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PATTERN1                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
    tree.end
    tree "HAPTICS_WF_REPEAT"
      sgroup "HAPTICS_WF_REPEAT (at 0x1c05e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c05e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   WF_REPEAT                                = " "0 (WF_REPEAT_1_TIMES),1 (WF_REPEAT_2_TIMES),2 (WF_REPEAT_4_TIMES),3 (WF_REPEAT_8_TIMES),4 (WF_REPEAT_16_TIMES),5 (WF_REPEAT_32_TIMES),6 (WF_REPEAT_64_TIMES),7 (WF_REPEAT_128_TIMES)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   WF_REPEAT_RSVD                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WF_S_REPEAT                              = " "0 (WF_S_REPEAT_1_TIMES),1 (WF_S_REPEAT_2_TIMES),2 (WF_S_REPEAT_4_TIMES),3 (WF_S_REPEAT_8_TIMES)"
    tree.end
    tree "HAPTICS_WF_S1"
      sgroup "HAPTICS_WF_S1 (at 0x1c060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S2"
      sgroup "HAPTICS_WF_S2 (at 0x1c061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S3"
      sgroup "HAPTICS_WF_S3 (at 0x1c062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S4"
      sgroup "HAPTICS_WF_S4 (at 0x1c063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S5"
      sgroup "HAPTICS_WF_S5 (at 0x1c064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S6"
      sgroup "HAPTICS_WF_S6 (at 0x1c065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S7"
      sgroup "HAPTICS_WF_S7 (at 0x1c066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S8"
      sgroup "HAPTICS_WF_S8 (at 0x1c067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_PLAY"
      sgroup "HAPTICS_PLAY (at 0x1c070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PLAY                                     = " "0 (STOP),1 (PLAY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PAUSE                                    = " "0 (CONTINUE),1 (PAUSE)"
    tree.end
    tree "HAPTICS_SEC_ACCESS"
      sgroup "HAPTICS_SEC_ACCESS (at 0x1c0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL2"
      sgroup "HAPTICS_PERPH_RESET_CTL2 (at 0x1c0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL3"
      sgroup "HAPTICS_PERPH_RESET_CTL3 (at 0x1c0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL4"
      sgroup "HAPTICS_PERPH_RESET_CTL4 (at 0x1c0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "HAPTICS_SPARE"
      sgroup "HAPTICS_SPARE (at 0x1c0df)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "HAPTICS_INT_TEST1"
      sgroup "HAPTICS_INT_TEST1 (at 0x1c0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "HAPTICS_INT_TEST_VAL"
      sgroup "HAPTICS_INT_TEST_VAL (at 0x1c0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_VAL                             = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_VAL                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "HAPTICS_TEST1"
      sgroup "HAPTICS_TEST1 (at 0x1c0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST2"
      sgroup "HAPTICS_TEST2 (at 0x1c0e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUTO_RES_EN                              = " "0 (AUTO_RES_DIS),1 (AUTO_RES_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   EXT_PWM_DTEST_SEL                        = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST3"
      sgroup "HAPTICS_TEST3 (at 0x1c0e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_ILIM_100MA                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_HI_Z                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_PFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TM_NFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_PFET_M_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NFET_M_ON                             = " "0, 1"
    tree.end
    tree "HAPTICS_TRIM_NUM"
      sgroup "HAPTICS_TRIM_NUM (at 0x1c0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "HAPTICS_REF_BUFF_TRIM"
      sgroup "HAPTICS_REF_BUFF_TRIM (at 0x1c0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
    tree "HAPTICS_ERR_AMP_TRIM"
      sgroup "HAPTICS_ERR_AMP_TRIM (at 0x1c0f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
  tree.end
tree.end
tree "IBB"
  tree "IBB"
    tree "IBB_REVISION1"
      sgroup "IBB_REVISION1 (at 0x1dc00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IBB_REVISION2"
      sgroup "IBB_REVISION2 (at 0x1dc01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IBB_REVISION3"
      sgroup "IBB_REVISION3 (at 0x1dc02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IBB_REVISION4"
      sgroup "IBB_REVISION4 (at 0x1dc03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IBB_PERPH_TYPE"
      sgroup "IBB_PERPH_TYPE (at 0x1dc04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IBB_PERPH_SUBTYPE"
      sgroup "IBB_PERPH_SUBTYPE (at 0x1dc05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IBB_STATUS1"
      sgroup "IBB_STATUS1 (at 0x1dc08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_NO_SC_FAULT),1 (MODULE_SHORT_CIRCUIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIMIT_ERROR                             = " "0 (NO_ILIMIT_ERROR),1 (ILIMIT_ERROR)"
    tree.end
    tree "IBB_STATUS2"
      sgroup "IBB_STATUS2 (at 0x1dc09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CURRENT_OUTPUT_VOLTAGE                   = "
    tree.end
    tree "IBB_STATUS3"
      sgroup "IBB_STATUS3 (at 0x1dc0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IBB_STATUS                               = "
    tree.end
    tree "IBB_INT_RT_STS"
      sgroup "IBB_INT_RT_STS (at 0x1dc10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "IBB_INT_SET_TYPE"
      sgroup "IBB_INT_SET_TYPE (at 0x1dc11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "IBB_INT_POLARITY_HIGH"
      sgroup "IBB_INT_POLARITY_HIGH (at 0x1dc12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_POLARITY_LOW"
      sgroup "IBB_INT_POLARITY_LOW (at 0x1dc13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_CLR"
      sgroup "IBB_INT_LATCHED_CLR (at 0x1dc14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "IBB_INT_EN_SET"
      sgroup "IBB_INT_EN_SET (at 0x1dc15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_EN_CLR"
      sgroup "IBB_INT_EN_CLR (at 0x1dc16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_STS"
      sgroup "IBB_INT_LATCHED_STS (at 0x1dc18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "IBB_INT_PENDING_STS"
      sgroup "IBB_INT_PENDING_STS (at 0x1dc19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "IBB_INT_MID_SEL"
      sgroup "IBB_INT_MID_SEL (at 0x1dc1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "IBB_INT_PRIORITY"
      sgroup "IBB_INT_PRIORITY (at 0x1dc1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE"
      sgroup "IBB_OUTPUT_VOLTAGE (at 0x1dc41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0 (DEFAULT_OUTPUT_VOLTAGE),1 (OVERRIDE_OUTPUT_VOLTAGE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "IBB_RING_SUPPRESSION_CTL"
      sgroup "IBB_RING_SUPPRESSION_CTL (at 0x1dc42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0 (RING_SUPPRESSION_DISABLED),1 (RING_SUPPRESSION_ENABLED)"
    tree.end
    tree "IBB_VREF_SEL"
      sgroup "IBB_VREF_SEL (at 0x1dc43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_SEL                                 = " "0 (SUMMIT_BG),1 (PMIC_BG)"
    tree.end
    tree "IBB_LCD_AMOLED_SEL"
      sgroup "IBB_LCD_AMOLED_SEL (at 0x1dc44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "IBB_MODULE_RDY"
      sgroup "IBB_MODULE_RDY (at 0x1dc45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (IBB_NOT_RDY),1 (IBB_RDY)"
    tree.end
    tree "IBB_ENABLE_CTL"
      sgroup "IBB_ENABLE_CTL (at 0x1dc46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SWIRE_RDY                                = " "0 (SWIRE_NOT_RDY),1 (SWIRE_RDY)"
    tree.end
    tree "IBB_PD_CTL"
      sgroup "IBB_PD_CTL (at 0x1dc47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_PD                                = " "0 (PD_DISABLE),1 (PD_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_FULLSTRENGTH),1 (PD_HALFSTRENGTH)"
    tree.end
    tree "IBB_CLK_DIV"
      sgroup "IBB_CLK_DIV (at 0x1dc48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_1"
      sgroup "IBB_IPLIMIT_STARTUP_CTL_1 (at 0x1dc49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_IPLIMIT_STEPPER                       = " "0 (DIS_IPLIMIT_STEPPER),1 (EN_IPLIMIT_STEPPER)"
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_2"
      sgroup "IBB_IPLIMIT_STARTUP_CTL_2 (at 0x1dc4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   STARTUP_IPLIMIT                          = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CURRENT_STEP_SIZE                        = " "0 (MA50),1 (MA100),2 (MA150),3 (MA200)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_STEPPER_CYCLES                   = " "0 (CYCLES_PER_STEP_8),1 (CYCLES_PER_STEP_16),2 (CYCLES_PER_STEP_32),3 (CYCLES_PER_STEP_64)"
    tree.end
    tree "IBB_CURRENT_LIMIT"
      sgroup "IBB_CURRENT_LIMIT (at 0x1dc4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ILIMIT_COUNT                             = " "0 (CYC8),1 (CYC16),2 (CYC32),3 (CYC64)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SET_CURRENT_MAX                          = "
    tree.end
    tree "IBB_CURRENT_SENSE"
      sgroup "IBB_CURRENT_SENSE (at 0x1dc4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_C_COMP                               = " "0 (CURR_SNS_COMP_CAP_50FF),1 (CURR_SNS_COMP_CAP_70FF)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_GAIN                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_LOOP_COMP_CTL"
      sgroup "IBB_LOOP_COMP_CTL (at 0x1dc4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_96PF),1 (COMP_CAP_106PF),2 (COMP_CAP_116PF),3 (COMP_CAP_126PF)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "IBB_SLOPE_COMP_CURRENT"
      sgroup "IBB_SLOPE_COMP_CURRENT (at 0x1dc4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP_CURRENT                       = " "0 (COMP_CURR_0P25UA),1 (COMP_CURR_0P5UA),2 (COMP_CURR_0P75UA),3 (COMP_CURR_1UA),4 (COMP_CURR_1P25UA),5 (COMP_CURR_1P5UA),6 (COMP_CURR_1P75UA),7 (COMP_CURR_2UA)"
    tree.end
    tree "IBB_INZERO_CTL"
      sgroup "IBB_INZERO_CTL (at 0x1dc4f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   INZERO_DELAY                             = " "0 (NS70),1 (NS35_1),2 (NS35_2),3 (NS25)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERRIDE_VOLTAGE_OFFSET                  = " "0 (DEFAULT_VOLTAGE_OFFSET),1 (OVERRIDE_VOLTAGE_OFFSET)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_M1MV),2 (VOFF_M4MV),3 (VOFF_M8MV),4 (VOFF_1MV),5 (VOFF_4MV),6 (VOFF_6MV),7 (VOFF_8MV)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_DETECT_ON                             = " "0 (INZERODET_ZERO),1 (INZERODET_EN)"
    tree.end
    tree "IBB_PS_CTL"
      sgroup "IBB_PS_CTL (at 0x1dc50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (DIS_PS),1 (EN_PS)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_THRESHOLD                             = " "0 (UA0),1 (UA0P5),2 (UA1),3 (UA1P5),4 (UA2),5 (UA2P5),6 (UA3),7 (UA3P5)"
    tree.end
    tree "IBB_PWM_CTL_1"
      sgroup "IBB_PWM_CTL_1 (at 0x1dc51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UNLIMITED_DUTY_CYCLE                     = " "0 (LIMITED_DUTY_CYCLE),1 (UNLIMITED_DUTY_CYCLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MAX_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
    tree.end
    tree "IBB_PWM_CTL_2"
      sgroup "IBB_PWM_CTL_2 (at 0x1dc52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   ERR_AMP_GAIN                             = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_BLANK_TIME                       = " "0 (NS20_1),1 (NS14),2 (NS20_2),3 (NS40)"
    tree.end
    tree "IBB_RDSON_MNGMNT"
      sgroup "IBB_RDSON_MNGMNT (at 0x1dc53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NFET_SLEW                                = " "0 (NFET_HALF_SLEW),1 (NFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_SLEW                                = " "0 (PFET_HALF_SLEW),1 (PFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERRIDE_NFET_SW_SIZE                    = " "0 (DEFAULT_NFET_SW_SIZE),1 (OVERRIDE_NFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   NFET_SW_SIZE                             = " "0 (LCD_NFET_HALF_SIZE),1 (LCD_NFET_FULL_SIZE),2 (AMOLED_NFET_HALF_SIZE),3 (AMOLED_NFET_FULL_SIZE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERRIDE_PFET_SW_SIZE                    = " "0 (DEFAULT_PFET_SW_SIZE),1 (OVERRIDE_PFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (LCD_PFET_HALF_SIZE),1 (LCD_PFET_FULL_SIZE),2 (AMOLED_PFET_HALF_SIZE),3 (AMOLED_PFET_FULL_SIZE)"
    tree.end
    tree "IBB_SHORT_CIRCUIT_CTL"
      sgroup "IBB_SHORT_CIRCUIT_CTL (at 0x1dc54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "IBB_VREG_OK_CTL"
      sgroup "IBB_VREG_OK_CTL (at 0x1dc55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VREG_NOT_OK_BLANK                     = " "0 (DIS_VREG_NOT_OK_BLANKING),1 (EN_VREG_NOT_OK_BLANKING)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VREG_NOT_OK_BLANKTIME                    = " "0 (MS8),1 (MS16),2 (MS32),3 (MS64)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US2),1 (US4),2 (US8),3 (US16)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_1"
      sgroup "IBB_NONOVERLAP_TIME_1 (at 0x1dc56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVERRIDE_NONOVERLAP                      = " "0 (DEFAULT_NONOVERLAP_TIME),1 (OVERRIDE_NONOVERLAP_TIME)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NONOVERLAP_PFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NONOVERLAP_NFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_2"
      sgroup "IBB_NONOVERLAP_TIME_2 (at 0x1dc57)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   P2N_MUX_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N2P_MUX_SEL                              = " "0, 1"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_1"
      sgroup "IBB_PWRUP_PWRDN_CTL_1 (at 0x1dc58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWRUP_DLY1_SRC                           = " "0 (BIAS_ACTIVE),1 (LAB_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWRUP_DLY1                            = " "0 (DIS_PWRUP_DLY1),1 (EN_PWRUP_DLY1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWRUP_DLY1                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWRDN_DLY2_SRC                           = " "0 (IBB_DIS),1 (IBB_DISCHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWRDN_DLY2                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_2"
      sgroup "IBB_PWRUP_PWRDN_CTL_2 (at 0x1dc59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WAIT_MBG_OK                              = " "0 (DIS_WAIT_MBG_OK),1 (EN_WAIT_MBG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IBB_DIS_DLY                              = " "0 (MS0),1 (MS1),2 (MS2),3 (MS4)"
    tree.end
    tree "IBB_SWIRE_CTL"
      sgroup "IBB_SWIRE_CTL (at 0x1dc5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OUTPUT_VOLTAGE_AT_ONE_PULSE              = "
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_INTL"
      sgroup "IBB_OUTPUT_VOLTAGE_INTL (at 0x1dc5b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_INTERNAL              = "
    tree.end
    tree "IBB_OUTPUT_SLEW_CTL"
      sgroup "IBB_OUTPUT_SLEW_CTL (at 0x1dc5c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DIGITAL_SLEW_CTL                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   STEP_INTERVAL_TIME                       = " "0 (MS0P25),1 (MS0P5),2 (MS1),3 (MS2),4 (MS4),5 (MS8),6 (MS16),7 (MS32)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD"
      sgroup "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD (at 0x1dc5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD    = "
    tree.end
    tree "IBB_RAMP_OFFSET"
      sgroup "IBB_RAMP_OFFSET (at 0x1dc5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_OFFSET                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_SOFT_START_CTL"
      sgroup "IBB_SOFT_START_CTL (at 0x1dc5f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START                               = " "0, 1, 2, 3"
    tree.end
    tree "IBB_SPARE_CTL"
      sgroup "IBB_SPARE_CTL (at 0x1dc60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UNDEFINED_LV                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   POFF_CTL                                 = " "0 (SLOWER_PFET_OFF),1 (FASTER_PFET_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   ADJUST_CURRENT_LIMIT                     = " "0 (DEFAULT_CURRENT_LIMIT),1 (M20PCT_LOWER_CURRENT_LIMIT),2 (P40PCT_HIGHER_CURRENT_LIMIT),3 (P20PCT_HIGHER_CURRENT_LIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "IBB_NLIMIT_DAC"
      sgroup "IBB_NLIMIT_DAC (at 0x1dc61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NLIMIT_DAC                               = " "0 (MA0),1 (MA80),2 (MA160),3 (MA240),4 (MA320),5 (MA400),6 (MA480),7 (MA560)"
    tree.end
    tree "IBB_SEC_ACCESS"
      sgroup "IBB_SEC_ACCESS (at 0x1dcd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IBB_PERPH_RESET_CTL1"
      sgroup "IBB_PERPH_RESET_CTL1 (at 0x1dcd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "IBB_PERPH_RESET_CTL2"
      sgroup "IBB_PERPH_RESET_CTL2 (at 0x1dcd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL3"
      sgroup "IBB_PERPH_RESET_CTL3 (at 0x1dcda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL4"
      sgroup "IBB_PERPH_RESET_CTL4 (at 0x1dcdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "IBB_INT_TEST1"
      sgroup "IBB_INT_TEST1 (at 0x1dce0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "IBB_INT_TEST_VAL"
      sgroup "IBB_INT_TEST_VAL (at 0x1dce1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "IBB_DTEST1_ACCESS"
      sgroup "IBB_DTEST1_ACCESS (at 0x1dce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1_ACCESS                            = "
    tree.end
    tree "IBB_DTEST2_ACCESS"
      sgroup "IBB_DTEST2_ACCESS (at 0x1dce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_ACCESS                            = "
    tree.end
    tree "IBB_DTEST3_ACCESS"
      sgroup "IBB_DTEST3_ACCESS (at 0x1dce4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3_ACCESS                            = "
    tree.end
    tree "IBB_DTEST4_ACCESS"
      sgroup "IBB_DTEST4_ACCESS (at 0x1dce5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_ACCESS                            = "
    tree.end
    tree "IBB_ATEST1_ACCESS"
      sgroup "IBB_ATEST1_ACCESS (at 0x1dce6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ATEST_GM_2UA),2 (ATEST_BIAS1UA),3 (DISCHARGE_RAMP_ATEST),4 (PREAMP_TRIM_OUT),5 (RESERVED),6 (PWM_COMP),7 (BKSP1)"
    tree.end
    tree "IBB_ATEST2_ACCESS"
      sgroup "IBB_ATEST2_ACCESS (at 0x1dce7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (VREF_BUFFF_TRIM2_OUT),3 (VREF),4 (ERROR_AMP_OUT_TRIM),5 (PWR_DRV_ATEST),6 (IPLIMIT),7 (KSP2)"
    tree.end
    tree "IBB_ATEST3_ACCESS"
      sgroup "IBB_ATEST3_ACCESS (at 0x1dce8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (REF_CAP_CHARGED),2 (TOP_RES_1),3 (DIVIDER_TOP),4 (IBB_VREF),5 (INM_PREAMP),6 (BOT_RES_1),7 (DAC_OUT)"
    tree.end
    tree "IBB_ATEST4_ACCESS"
      sgroup "IBB_ATEST4_ACCESS (at 0x1dce9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (PSKIP_THRESHOLD),3 (VFLOAT),4 (VREG_OK),5 (RING_KILL_MV),6 (PULSE_SKIP),7 (N_OFF_LV)"
    tree.end
    tree "IBB_TEST_CTL_1"
      sgroup "IBB_TEST_CTL_1 (at 0x1dcea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_OUTPUT_VOLTAGE_TEST                   = " "0 (DIS),1 (EN)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OUTPUT_VOLTAGE_TEST_MODE                 = " "0 (VM6P1),1 (VM6P2),2 (VM6P3),3 (VM6P4)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RDSON_TEST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
    tree.end
    tree "IBB_TEST_CTL_2"
      sgroup "IBB_TEST_CTL_2 (at 0x1dceb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dceb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdceb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_PWR_STAGE_OFF                      = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ERRAMP_TRIM_DIS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ERRAMP_TRIM_CALIB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_TRIM_INZERO_OFFSET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DISABLE_PREAMP_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CALIB_BUFF_TRIM                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALIB_PREAMP_TRIM                        = " "0, 1"
    tree.end
    tree "IBB_DEBOUNCER_OVERRIDE"
      sgroup "IBB_DEBOUNCER_OVERRIDE (at 0x1dcec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEB_ILIMIT                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "IBB_TEST_CTL_3"
      sgroup "IBB_TEST_CTL_3 (at 0x1dced)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dced0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdced0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STATUS3_CTRL_SEL                         = "
    tree.end
    tree "IBB_TRIM_NUM"
      sgroup "IBB_TRIM_NUM (at 0x1dcf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "IBB_TRIM_CTL1"
      sgroup "IBB_TRIM_CTL1 (at 0x1dcf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
    tree "IBB_TRIM_CTL2"
      sgroup "IBB_TRIM_CTL2 (at 0x1dcf2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_BIAS_GM                             = "
    tree.end
    tree "IBB_TRIM_CTL3"
      sgroup "IBB_TRIM_CTL3 (at 0x1dcf3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_PREAMP_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL4"
      sgroup "IBB_TRIM_CTL4 (at 0x1dcf4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_INZERO_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL5"
      sgroup "IBB_TRIM_CTL5 (at 0x1dcf5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_REF_DAC_BUFF                        = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LAB"
  tree "LAB"
    tree "LAB_REVISION1"
      sgroup "LAB_REVISION1 (at 0x1de00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LAB_REVISION2"
      sgroup "LAB_REVISION2 (at 0x1de01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LAB_REVISION3"
      sgroup "LAB_REVISION3 (at 0x1de02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LAB_REVISION4"
      sgroup "LAB_REVISION4 (at 0x1de03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LAB_PERPH_TYPE"
      sgroup "LAB_PERPH_TYPE (at 0x1de04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LAB_PERPH_SUBTYPE"
      sgroup "LAB_PERPH_SUBTYPE (at 0x1de05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LAB_STATUS1"
      sgroup "LAB_STATUS1 (at 0x1de08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_NO_SC_FAULT),1 (MODULE_SHORT_CIRCUIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LAB_STATUS                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LAB_INT_RT_STS"
      sgroup "LAB_INT_RT_STS (at 0x1de10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LAB_INT_SET_TYPE"
      sgroup "LAB_INT_SET_TYPE (at 0x1de11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LAB_INT_POLARITY_HIGH"
      sgroup "LAB_INT_POLARITY_HIGH (at 0x1de12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_POLARITY_LOW"
      sgroup "LAB_INT_POLARITY_LOW (at 0x1de13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_CLR"
      sgroup "LAB_INT_LATCHED_CLR (at 0x1de14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LAB_INT_EN_SET"
      sgroup "LAB_INT_EN_SET (at 0x1de15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_EN_CLR"
      sgroup "LAB_INT_EN_CLR (at 0x1de16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_STS"
      sgroup "LAB_INT_LATCHED_STS (at 0x1de18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LAB_INT_PENDING_STS"
      sgroup "LAB_INT_PENDING_STS (at 0x1de19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LAB_INT_MID_SEL"
      sgroup "LAB_INT_MID_SEL (at 0x1de1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LAB_INT_PRIORITY"
      sgroup "LAB_INT_PRIORITY (at 0x1de1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LAB_OUTPUT_VOLTAGE"
      sgroup "LAB_OUTPUT_VOLTAGE (at 0x1de41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "LAB_RING_SUPPRESSION_CTL"
      sgroup "LAB_RING_SUPPRESSION_CTL (at 0x1de42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0, 1"
    tree.end
    tree "LAB_VREF_SEL"
      sgroup "LAB_VREF_SEL (at 0x1de43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_SEL                                 = " "0 (SUMMIT_BG),1 (PMIC_BG)"
    tree.end
    tree "LAB_LCD_AMOLED_SEL"
      sgroup "LAB_LCD_AMOLED_SEL (at 0x1de44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "LAB_MODULE_RDY"
      sgroup "LAB_MODULE_RDY (at 0x1de45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (LAB_NOT_RDY),1 (LAB_RDY)"
    tree.end
    tree "LAB_ENABLE_CTL"
      sgroup "LAB_ENABLE_CTL (at 0x1de46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
    tree.end
    tree "LAB_PD_CTL"
      sgroup "LAB_PD_CTL (at 0x1de47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PULLDOWN                             = " "0 (EN_PD),1 (DIS_PD)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_WEAK),1 (PD_STRONG)"
    tree.end
    tree "LAB_CLK_DIV"
      sgroup "LAB_CLK_DIV (at 0x1de48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "LAB_IBB_EN_RDY"
      sgroup "LAB_IBB_EN_RDY (at 0x1de49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IBB_EN_RDY                               = " "0 (IBB_EN_NOT_RDY),1 (IBB_EN_RDY)"
    tree.end
    tree "LAB_CURRENT_LIMIT"
      sgroup "LAB_CURRENT_LIMIT (at 0x1de4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OVERRIDE_CURRENT_MAX                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LAB_CURRENT_SENSE"
      sgroup "LAB_CURRENT_SENSE (at 0x1de4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ISENSE_TAP                               = " "0 (X0P8),1 (X0P9),2 (X1),3 (X1P1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ISENSE_GAIN                              = " "0 (X0P5),1 (X1),2 (X1P5),3 (X2)"
    tree.end
    tree "LAB_LOOP_COMP_CTL"
      sgroup "LAB_LOOP_COMP_CTL (at 0x1de4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_16PF),1 (COMP_CAP_24PF),2 (COMP_CAP_32PF),3 (COMP_CAP_40PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (COMP_RES_100K),1 (COMP_RES_200K),2 (COMP_RES_500K),3 (COMP_RES_600K)"
    tree.end
    tree "LAB_SLOPE_COMP_CURRENT"
      sgroup "LAB_SLOPE_COMP_CURRENT (at 0x1de4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SLOPE_COMP_CURRENT                       = " "0 (COMP_CURR_4P5UA),1 (COMP_CURR_4UA),2 (COMP_CURR_3P5UA),3 (COMP_CURR_3UA),4 (COMP_CURR_2P5UA),5 (COMP_CURR_2UA),6 (COMP_CURR_1P5UA),7 (COMP_CURR_1UA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DOUBLER                       = " "0 (DO_NOT_DOUBLE),1 (DOUBLE)"
    tree.end
    tree "LAB_IP_ZERO_DETECTOR"
      sgroup "LAB_IP_ZERO_DETECTOR (at 0x1de4f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_1P5MV),2 (VOFF_3MV),3 (VOFF_4P5MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_DETECT_ON                             = " "0 (IPZERODET_ZERO),1 (IPZERODET_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTOZERO_ON                              = " "0 (AUTO_ZERORING_DISABLED),1 (AUTO_ZEROING_ENABLED)"
    tree.end
    tree "LAB_PS_CTL"
      sgroup "LAB_PS_CTL (at 0x1de50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (PWM),1 (PULSE_SKIP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_DIG_PS                               = " "0 (ANALOG_PS),1 (DIGITAL_PS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SEL_PS_TABLE                             = " "0 (PS_TABLE_0),1 (PS_TABLE_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PS_THRESHOLD                             = " "0 (MA20),1 (MA30),2 (MA40),3 (MA50)"
    tree.end
    tree "LAB_PWM_CTL_1"
      sgroup "LAB_PWM_CTL_1 (at 0x1de51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MAX_DUTY_CYCLE                        = " "0 (DIS_MAX_DUTY),1 (EN_MAX_DUTY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_D_MODULATION                          = " "0 (DIS_D_MODULATION),1 (EN_D_MODULATION)"
    tree.end
    tree "LAB_PWM_CTL_2"
      sgroup "LAB_PWM_CTL_2 (at 0x1de52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERR_AMP_GAIN                             = " "0 (LOW_GAIN),1 (HIGH_GAIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_AUTO_ASYNC                            = " "0 (DIS_AUTO_AYSNC),1 (EN_AUTO_ASYNC)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BLANK_TIME                               = " "0 (NS5),1 (NS10),2 (NS20),3 (NS35)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (PCT3P9),1 (PCT5P8),2 (PCT7P7),3 (PCT9P2)"
    tree.end
    tree "LAB_RDSON_MNGMNT"
      sgroup "LAB_RDSON_MNGMNT (at 0x1de53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   NFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
    tree.end
    tree "LAB_SHORT_CIRCUIT_CTL"
      sgroup "LAB_SHORT_CIRCUIT_CTL (at 0x1de54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "LAB_VREG_OK_CTL"
      sgroup "LAB_VREG_OK_CTL (at 0x1de55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US10),1 (US20),2 (US30),3 (US40)"
    tree.end
    tree "LAB_AFVC"
      sgroup "LAB_AFVC (at 0x1de5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFVC_ENABLE                              = " "0 (AFVC_DIS),1 (AFVC_EN)"
    tree.end
    tree "LAB_PRECHARGE_CTL"
      sgroup "LAB_PRECHARGE_CTL (at 0x1de5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FAST_PRECHARGE                           = " "0 (SLOW_PRECHARGE),1 (FAST_PRECHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_PRECHARGE_TIME            = " "0 (US200),1 (US300),2 (US400),3 (US500)"
    tree.end
    tree "LAB_SOFT_START_CTL"
      sgroup "LAB_SOFT_START_CTL (at 0x1de5f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_SOFT_START_TIME           = " "0 (US200),1 (US400),2 (US600),3 (US800)"
    tree.end
    tree "LAB_SPARE_CTL"
      sgroup "LAB_SPARE_CTL (at 0x1de60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARES                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_SPIKE_SUPPRESS                       = " "0 (EN_SPIKE_SUPPRESS),1 (DIS_SPIKE_SUPPRESS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_NX_ILIMIT                             = " "0 (DIS_NX_ILIMIT),1 (EN_NX_ILIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "LAB_SEC_ACCESS"
      sgroup "LAB_SEC_ACCESS (at 0x1ded0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LAB_PERPH_RESET_CTL1"
      sgroup "LAB_PERPH_RESET_CTL1 (at 0x1ded8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LAB_PERPH_RESET_CTL2"
      sgroup "LAB_PERPH_RESET_CTL2 (at 0x1ded9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL3"
      sgroup "LAB_PERPH_RESET_CTL3 (at 0x1deda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL4"
      sgroup "LAB_PERPH_RESET_CTL4 (at 0x1dedb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LAB_INT_TEST1"
      sgroup "LAB_INT_TEST1 (at 0x1dee0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LAB_INT_TEST_VAL"
      sgroup "LAB_INT_TEST_VAL (at 0x1dee1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LAB_DTEST1_ACCESS"
      sgroup "LAB_DTEST1_ACCESS (at 0x1dee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (CURR_COMP),2 (DUTYCYCLE_COMP),3 (D0P3_COMP),4 (VREG_OK_COMP),5 (LAB_EN),6 (SHORT_ALARM),7 (PULSESKIP_COMP)"
    tree.end
    tree "LAB_DTEST2_ACCESS"
      sgroup "LAB_DTEST2_ACCESS (at 0x1dee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (SWIRE_LAB_EN),2 (NGATE),3 (CLOCK_19P2M),4 (ZX_COMP),5 (DIG_PS_2),6 (PRECHARGE_TIMEOUT),7 (PSLOW_COMP)"
    tree.end
    tree "LAB_DTEST3_ACCESS"
      sgroup "LAB_DTEST3_ACCESS (at 0x1dee4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (EN_RISEDLY),2 (PGATE),3 (SENSE_SW_CNT),4 (SSEND_COMP),5 (DIG_PS_1),6 (CLK_19P2M_REQ),7 (CLK_DLY)"
    tree.end
    tree "LAB_DTEST4_ACCESS"
      sgroup "LAB_DTEST4_ACCESS (at 0x1dee5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VOK_DEBOUNCE),2 (SHORT_ALARM_DEBOUNCE),3 (DIS_CHG_FNC),4 (ILIMIT_COMP),5 (DIG_PS_0),6 (CLK_MASK),7 (MAXD)"
    tree.end
    tree "LAB_ATEST1_ACCESS"
      sgroup "LAB_ATEST1_ACCESS (at 0x1dee6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ERRAMP_OUT),2 (VREF1P25_BUF),3 (PFET_D),4 (VBSP_UNTRIM),5 (VC_TRIM_OUT),6 (PVDD_DIV_D0P3),7 (NO_SIGNAL_2)"
    tree.end
    tree "LAB_ATEST2_ACCESS"
      sgroup "LAB_ATEST2_ACCESS (at 0x1dee7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (VOUT_DIV),2 (VOUT_DIV_VOKCOMP),3 (PVDD_DIV_DUTYLOW),4 (VOUT_1P25),5 (PVDD_DIV_CURR),6 (PGND),7 (VREF_ERRAMP)"
    tree.end
    tree "LAB_ATEST3_ACCESS"
      sgroup "LAB_ATEST3_ACCESS (at 0x1dee8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_EA_SS),2 (VREF_PS),3 (NFET_DSNS)"
    tree.end
    tree "LAB_ATEST4_ACCESS"
      sgroup "LAB_ATEST4_ACCESS (at 0x1dee9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_SSEND_COMP),2 (PFET_S),3 (IMAX_VREF)"
    tree.end
    tree "LAB_TEST_CTL"
      sgroup "LAB_TEST_CTL (at 0x1deea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_NFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SCALE_ILIM                               = " "0 (X1),1 (X0P5),2 (X0P33),3 (X0P25)"
    tree.end
    tree "LAB_DEBOUNCER_OVERRIDE"
      sgroup "LAB_DEBOUNCER_OVERRIDE (at 0x1deeb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deeb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeeb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LAB_TRIM_NUM"
      sgroup "LAB_TRIM_NUM (at 0x1def0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80def00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LAB_TRIM_CTL1"
      sgroup "LAB_TRIM_CTL1 (at 0x1def1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80def10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_EN                                  = " "0 (TRIM_ENB),1 (TRIM_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIM_VALUE_SIGN                          = " "0 (NEG_OFFS_ADDING),1 (POS_OFFS_ADDING)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      sgroup "LDO1_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      sgroup "LDO1_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      sgroup "LDO1_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      sgroup "LDO1_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      sgroup "LDO1_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      sgroup "LDO1_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      sgroup "LDO1_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO1_STATUS2"
      sgroup "LDO1_STATUS2 (at 0x14009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      sgroup "LDO1_STATUS3 (at 0x1400a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      sgroup "LDO1_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      sgroup "LDO1_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      sgroup "LDO1_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      sgroup "LDO1_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      sgroup "LDO1_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      sgroup "LDO1_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      sgroup "LDO1_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      sgroup "LDO1_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      sgroup "LDO1_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      sgroup "LDO1_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      sgroup "LDO1_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      sgroup "LDO1_VOLTAGE_CTL1 (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      sgroup "LDO1_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      sgroup "LDO1_MODE_CTL2 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      sgroup "LDO1_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      sgroup "LDO1_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      sgroup "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      sgroup "LDO1_SOFT_START_CTL (at 0x1404c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      sgroup "LDO1_CONFIG_CTL (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      sgroup "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      sgroup "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      sgroup "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      sgroup "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      sgroup "LDO1_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      sgroup "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      sgroup "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      sgroup "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      sgroup "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      sgroup "LDO1_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      sgroup "LDO1_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      sgroup "LDO1_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      sgroup "LDO1_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      sgroup "LDO1_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      sgroup "LDO1_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS2"
      sgroup "MISC_STATUS2 (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0 (USE_LDO),1 (reserved),2 (DO_NOT_USE_LDO),3 (reserved)"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VPRE_CHARGE_SEL                          = " "0 (VPRE_CHARGE_LOW_RANGE_0P35V),1 (VPRE_CHARGE_LOW_RANGE_0P40V),2 (VPRE_CHARGE_LOW_RANGE_0P45V),3 (VPRE_CHARGE_LOW_RANGE_0P50V)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_IBG_DLY_DISABLED),1 (BYPASS_IBG_DLY_ENABLED)"
    tree.end
    tree "MISC_LED_IZTC_CTL"
      sgroup "MISC_LED_IZTC_CTL (at 0x947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ATEST_LED_IZTC                        = " "0 (ATEST_IZTC_DISABLED),1 (ATEST_IZTC_ENABLED)"
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x949)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VDD_IO_PRECISE_DET_DIS                   = " "0 (VDD_IO_PRECISE_SET_ENABLED),1 (VDD_IO_PRECISE_SET_DISABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   MISC_CTL                                 = "
    tree.end
    tree "MISC_TX_GTR_THRES_CTL"
      sgroup "MISC_TX_GTR_THRES_CTL (at 0x94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TX_GTR_THRES_REG                         = " "0 (TRANSMIT_OVER),1 (GSM_TRANSMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_GTR_THRES_SEL                         = " "0, 1"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MISC_CSIR_7_0"
      sgroup "MISC_CSIR_7_0 (at 0x9f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_7_0                                 = "
    tree.end
    tree "MISC_CSIR_15_8"
      sgroup "MISC_CSIR_15_8 (at 0x9f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_15_8                                = "
    tree.end
    tree "MISC_IZTC_TRIM"
      sgroup "MISC_IZTC_TRIM (at 0x9f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IZTC_TRIM                                = "
    tree.end
    tree "MISC_IZTC_TRIM_PROCESS"
      sgroup "MISC_IZTC_TRIM_PROCESS (at 0x9f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IZTC_TRIM_PROCESS                        = "
    tree.end
    tree "MISC_TRIM_ERROR_RC19P2_CLK"
      sgroup "MISC_TRIM_ERROR_RC19P2_CLK (at 0x9f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_ERROR_RC19P2_CLK                    = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      sgroup "PBS_CLIENT5_STATUS1 (at 0x7609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      sgroup "PBS_CLIENT6_STATUS1 (at 0x7709)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      sgroup "PBS_CLIENT7_REVISION1 (at 0x7800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      sgroup "PBS_CLIENT7_REVISION2 (at 0x7801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      sgroup "PBS_CLIENT7_REVISION3 (at 0x7802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      sgroup "PBS_CLIENT7_REVISION4 (at 0x7803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      sgroup "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      sgroup "PBS_CLIENT7_STATUS0 (at 0x7808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      sgroup "PBS_CLIENT7_STATUS1 (at 0x7809)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      sgroup "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      sgroup "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      sgroup "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      sgroup "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      sgroup "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      sgroup "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      sgroup "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      sgroup "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      sgroup "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      sgroup "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      sgroup "PBS_CLIENT7_EN_CTL (at 0x7846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      sgroup "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      sgroup "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      sgroup "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      sgroup "PBS_CLIENT8_REVISION1 (at 0x7900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      sgroup "PBS_CLIENT8_REVISION2 (at 0x7901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      sgroup "PBS_CLIENT8_REVISION3 (at 0x7902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      sgroup "PBS_CLIENT8_REVISION4 (at 0x7903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      sgroup "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      sgroup "PBS_CLIENT8_STATUS0 (at 0x7908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      sgroup "PBS_CLIENT8_STATUS1 (at 0x7909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      sgroup "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      sgroup "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      sgroup "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      sgroup "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      sgroup "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      sgroup "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      sgroup "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x80791a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x791a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      sgroup "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x80791b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x791b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      sgroup "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      sgroup "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      sgroup "PBS_CLIENT8_EN_CTL (at 0x7946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      sgroup "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      sgroup "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      sgroup "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        set &access:&cmd_addr %l 0x8079e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x79e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_RAM_CFG1"
      sgroup "PBS_CORE_RAM_CFG1 (at 0x70a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG1"
      sgroup "PBS_CORE_NVM_CFG1 (at 0x70a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG2"
      sgroup "PBS_CORE_NVM_CFG2 (at 0x70a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPE                                     = " "0 (OTP),1 (ROM)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACCESS                                   = " "0 (WRITE_1200US_READ_800NS_INSTR_PR_1510NS),1 (WRITE_600US_READ_400NS_INSTR_PR_940NS),2 (WRITE_300US_READ_200NS_INSTR_PR_730NS),3 (reserved)"
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "PBS_CORE_RAM_READ_MARGIN"
      sgroup "PBS_CORE_RAM_READ_MARGIN (at 0x70e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RM                                       = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   POFF_FAULT_OCCURRED                      = " "0 (NO_FAULT),1 (FAULT_OCCURRED)"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL"
      sgroup "PON_RESERVED_FAULT_RESET_CTL (at 0x868)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL2"
      sgroup "PON_RESERVED_FAULT_RESET_CTL2 (at 0x869)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_DEBOUNCE                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_DEBOUNCE_DLY                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_UVLO_DLY                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   AVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_DVDD_VPH"
      sgroup "PON_DVDD_VPH (at 0x88b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_PON_DVDDREG),3 (DVDD_SRC_FROM_PON_DVDDREG1)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_DEBUG_CTL"
      sgroup "PON_DEBUG_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_50K)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      sgroup "PON_DEBUG_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST2_DVDD_INT                          = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      sgroup "PON_PON_CNTL_3_TRIM (at 0x8f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_4_TRIM"
      sgroup "PON_PON_CNTL_4_TRIM (at 0x8f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "PWM"
  tree "PWM"
    tree "PWM_REVISION1"
      sgroup "PWM_REVISION1 (at 0x1b000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM_REVISION2"
      sgroup "PWM_REVISION2 (at 0x1b001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM_PERPH_TYPE"
      sgroup "PWM_PERPH_TYPE (at 0x1b004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM_PERPH_SUBTYPE"
      sgroup "PWM_PERPH_SUBTYPE (at 0x1b005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM_PWM_SIZE_CLK"
      sgroup "PWM_PWM_SIZE_CLK (at 0x1b041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "PWM_PWM_FREQ_PREDIV_CLK"
      sgroup "PWM_PWM_FREQ_PREDIV_CLK (at 0x1b042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "PWM_PWM_TYPE_CONFIG"
      sgroup "PWM_PWM_TYPE_CONFIG (at 0x1b043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "PWM_PWM_VALUE_LSB"
      sgroup "PWM_PWM_VALUE_LSB (at 0x1b044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "PWM_PWM_VALUE_MSB"
      sgroup "PWM_PWM_VALUE_MSB (at 0x1b045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "PWM_ENABLE_CONTROL"
      sgroup "PWM_ENABLE_CONTROL (at 0x1b046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0 (PWM_DISABLE),1 (PWM_ENABLE)"
    tree.end
    tree "PWM_PWM_SYNC"
      sgroup "PWM_PWM_SYNC (at 0x1b047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0, 1"
    tree.end
    tree "PWM_SEC_ACCESS"
      sgroup "PWM_SEC_ACCESS (at 0x1b0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM_PERPH_RESET_CTL1"
      sgroup "PWM_PERPH_RESET_CTL1 (at 0x1b0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PWM_PERPH_RESET_CTL2"
      sgroup "PWM_PERPH_RESET_CTL2 (at 0x1b0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_PERPH_RESET_CTL3"
      sgroup "PWM_PERPH_RESET_CTL3 (at 0x1b0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_PERPH_RESET_CTL4"
      sgroup "PWM_PERPH_RESET_CTL4 (at 0x1b0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PWM_TEST1"
      sgroup "PWM_TEST1 (at 0x1b0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (PWM_OUT),2 (reserved),3 (reserved)"
    tree.end
    tree "PWM_TEST2"
      sgroup "PWM_TEST2 (at 0x1b0e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (reserved),2 (PWM_OUT),3 (reserved)"
    tree.end
    tree "PWM_TEST3"
      sgroup "PWM_TEST3 (at 0x1b0e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_GEN_BYPASS                           = " "0 (BYPASS_DISABLE),1 (BYPASS_ENABLE)"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SBL_ID_0"
      sgroup "REVID_SBL_ID_0 (at 0x150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_SBL_ID_1"
      sgroup "REVID_SBL_ID_1 (at 0x151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_PBS_OTP_ID_0"
      sgroup "REVID_PBS_OTP_ID_0 (at 0x154)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_REV_ID_SPARE_0"
      sgroup "REVID_REV_ID_SPARE_0 (at 0x160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_REV_ID_SPARE_1"
      sgroup "REVID_REV_ID_SPARE_1 (at 0x161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TRIM_NUM"
      sgroup "REVID_TRIM_NUM (at 0x1f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "REVID_TP_REV"
      sgroup "REVID_TP_REV (at 0x1f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TP_REV                                   = "
    tree.end
    tree "REVID_FAB_ID"
      sgroup "REVID_FAB_ID (at 0x1f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAB_ID                                   = "
    tree.end
    tree "REVID_WAFER_ID"
      sgroup "REVID_WAFER_ID (at 0x1f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WAFER_ID                                 = "
    tree.end
    tree "REVID_X_COORD"
      sgroup "REVID_X_COORD (at 0x1f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   X_COORD                                  = "
    tree.end
    tree "REVID_Y_COORD"
      sgroup "REVID_Y_COORD (at 0x1f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   Y_COORD                                  = "
    tree.end
    tree "REVID_LOT_ID_11_10"
      sgroup "REVID_LOT_ID_11_10 (at 0x1f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_11_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_10_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_10_09"
      sgroup "REVID_LOT_ID_10_09 (at 0x1f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_10_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_09_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_09_08"
      sgroup "REVID_LOT_ID_09_08 (at 0x1f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_09_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_08_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_07_06"
      sgroup "REVID_LOT_ID_07_06 (at 0x1f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_07_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_06_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_06_05"
      sgroup "REVID_LOT_ID_06_05 (at 0x1fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_06_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_05_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_05_04"
      sgroup "REVID_LOT_ID_05_04 (at 0x1fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_05_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_04_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_03_02"
      sgroup "REVID_LOT_ID_03_02 (at 0x1fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_03_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_02_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_02_01"
      sgroup "REVID_LOT_ID_02_01 (at 0x1fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_02_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_01_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_01_00"
      sgroup "REVID_LOT_ID_01_00 (at 0x1fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_01_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_00_5_0                            = "
    tree.end
    tree "REVID_MFG_ID_SPARE"
      sgroup "REVID_MFG_ID_SPARE (at 0x1ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "SMBCHGL_BAT_IF"
  tree "SMBCHGL_BAT_IF"
    tree "SMBCHGL_BAT_IF_PERPH_TYPE"
      sgroup "SMBCHGL_BAT_IF_PERPH_TYPE (at 0x1204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHGL_BAT_IF_PERPH_SUBTYPE"
      sgroup "SMBCHGL_BAT_IF_PERPH_SUBTYPE (at 0x1205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHGL_BAT_IF_BAT_PRES_STATUS"
      sgroup "SMBCHGL_BAT_IF_BAT_PRES_STATUS (at 0x1208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_PRES                                 = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_RT_STS"
      sgroup "SMBCHGL_BAT_IF_INT_RT_STS (at 0x1210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_RT_STS                  = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_SET_TYPE"
      sgroup "SMBCHGL_BAT_IF_INT_SET_TYPE (at 0x1211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_TYPE                    = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_POLARITY_HIGH"
      sgroup "SMBCHGL_BAT_IF_INT_POLARITY_HIGH (at 0x1212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_HIGH                    = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_POLARITY_LOW"
      sgroup "SMBCHGL_BAT_IF_INT_POLARITY_LOW (at 0x1213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LOW                     = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_LATCHED_CLR"
      sgroup "SMBCHGL_BAT_IF_INT_LATCHED_CLR (at 0x1214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_EN_SET"
      sgroup "SMBCHGL_BAT_IF_INT_EN_SET (at 0x1215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_SET                  = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_EN_CLR"
      sgroup "SMBCHGL_BAT_IF_INT_EN_CLR (at 0x1216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_CLR                  = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_LATCHED_STS"
      sgroup "SMBCHGL_BAT_IF_INT_LATCHED_STS (at 0x1218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_STS             = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_PENDING_STS"
      sgroup "SMBCHGL_BAT_IF_INT_PENDING_STS (at 0x1219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_PENDNG_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_PENDING_STS             = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_MID_SEL"
      sgroup "SMBCHGL_BAT_IF_INT_MID_SEL (at 0x121a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_PRIORITY"
      sgroup "SMBCHGL_BAT_IF_INT_PRIORITY (at 0x121b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_SHIP_MODE"
      sgroup "SMBCHGL_BAT_IF_SHIP_MODE (at 0x1240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHIP_MODE_ENB                            = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_CLR_DEAD_BAT_TIMER"
      sgroup "SMBCHGL_BAT_IF_CLR_DEAD_BAT_TIMER (at 0x1241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLR_DEAD_BAT_TIMER                       = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_CMD_CHG"
      sgroup "SMBCHGL_BAT_IF_CMD_CHG (at 0x1242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTG_BYPASS_CMD                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WIRELESS_CHG_DIS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CMD_CHG_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STAT_OUTPUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FC_COM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_BAT_CHG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_CMD_CHG_LED"
      sgroup "SMBCHGL_BAT_IF_CMD_CHG_LED (at 0x1243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CHG_LED_EXTRA                            = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CHG_LED_BLINKING_CFG                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_SW_CTRL                               = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_SEC_ACCESS"
      sgroup "SMBCHGL_BAT_IF_SEC_ACCESS (at 0x12d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHGL_BAT_IF_PERPH_RESET_CTL2"
      sgroup "SMBCHGL_BAT_IF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_PERPH_RESET_CTL3"
      sgroup "SMBCHGL_BAT_IF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_PERPH_RESET_CTL4"
      sgroup "SMBCHGL_BAT_IF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_SPARE"
      sgroup "SMBCHGL_BAT_IF_SPARE (at 0x12df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_TEST1"
      sgroup "SMBCHGL_BAT_IF_INT_TEST1 (at 0x12e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_INT_TEST_VAL"
      sgroup "SMBCHGL_BAT_IF_INT_TEST_VAL (at 0x12e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_INT_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_INT_VAL                 = " "0, 1"
    tree.end
    tree "SMBCHGL_BAT_IF_TRIM_NUM"
      sgroup "SMBCHGL_BAT_IF_TRIM_NUM (at 0x12f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHGL_BAT_IF_VBL_CFG"
      sgroup "SMBCHGL_BAT_IF_VBL_CFG (at 0x12f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOW_BAT_THRESHOLD                        = "
    tree.end
    tree "SMBCHGL_BAT_IF_VBL_SEL_CFG"
      sgroup "SMBCHGL_BAT_IF_VBL_SEL_CFG (at 0x12f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VBL_SEL_CFG_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VBL_SEL_CFG_6                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SYSOK_BMA_OPTION                         = " "0 (SYSOK_WAIT),1 (SYSOK_NO_WAIT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BM_IP                                    = " "0 (BMA_CHG_DIS),1 (BMA_CHG_TERM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_BM_DONE                            = " "0 (NEW_DMA_DONE),1 (OLD_BMA_DONE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBAT_LOW_STATE                           = " "0 (LOW_BATT_DG_LOW),1 (LOW_BATT_DG_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_THRESH_5VTO9V                       = " "0 (AICL_6V_OPTS),1 (AICL_4V_OPTS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCD_TIMEOUT_DELAY                        = " "0 (DCD_600MS),1 (DCD_300MS)"
    tree.end
    tree "SMBCHGL_BAT_IF_BM_CFG"
      sgroup "SMBCHGL_BAT_IF_BM_CFG (at 0x12f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BMD_RMV_CFG                              = " "0 (BMD_RMV_80US),1 (BMD_RMV_160US),2 (BMD_RMV_320US),3 (BMD_RMV_640US)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_FET_CFG                              = " "0 (BATT_FET_NORMAL),1 (BATT_FET_OVERRIDE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_MISSING_INPUT_PLUGIN                 = " "0 (BMA_PLUG_IN_DIS),1 (BMA_PLUG_IN_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISSING_2S6_POLLER                   = " "0 (BMA_POLLER_DIS),1 (BMA_POLLER_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISSING_ALGORITHM                    = " "0 (BMA_DIS),1 (BMA_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_MISSING_PIN_SRC                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHGL_BAT_IF_CFG_SYSMIN"
      sgroup "SMBCHGL_BAT_IF_CFG_SYSMIN (at 0x12f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SYSMIN                               = " "0 (SYSMIN_3P15),1 (SYSMIN_3P45),2 (SYSMIN_3P6),3 (SYSMIN_3P60)"
    tree.end
    tree "SMBCHGL_BAT_IF_CFG_SYSTH"
      sgroup "SMBCHGL_BAT_IF_CFG_SYSTH (at 0x12f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_EN_100M                              = " "0 (VSYS_VBATT_TRACK_200MV),1 (VSYS_VBATT_TRACK_100MV)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_SYSTH                                = " "0 (VSYS_SYSMAX),1 (VSYS_VBATT)"
    tree.end
    tree "SMBCHGL_BAT_IF_SS_CFG"
      sgroup "SMBCHGL_BAT_IF_SS_CFG (at 0x12f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_NO_SS                                = " "0 (SS_EN),1 (SS_DIS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SS_SEL                               = " "0 (SS_SEL_0),1 (SS_SEL_DIV2),2 (SS_SEL_DIV4),3 (SS_SEL_DIV8)"
    tree.end
    tree "SMBCHGL_BAT_IF_TRIM7"
      sgroup "SMBCHGL_BAT_IF_TRIM7 (at 0x12f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TR_STDBYOSC_TEMP_TRIM                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TLLS                                 = " "0 (OTST1_92C),1 (OTST1_101C)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM7_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_EN_FREQFOLD                          = " "0 (FREQ_FOLDBACK_DIS),1 (FREQ_FOLDBACK_EN)"
    tree.end
    tree "SMBCHGL_BAT_IF_CFG_BB_CLMP_SEL"
      sgroup "SMBCHGL_BAT_IF_CFG_BB_CLMP_SEL (at 0x12f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   TR_STDBYOSC_MAIN_TRIM                    = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BB_CLMP_SEL                          = " "0 (CFG_BB_CLMP_2P0),1 (CFG_BB_CLMP_2P2),2 (CFG_BB_CLMP_2P4),3 (reserved)"
    tree.end
    tree "SMBCHGL_BAT_IF_TRIM9"
      sgroup "SMBCHGL_BAT_IF_TRIM9 (at 0x12f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_EN_OS_ZD                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_ENB_SC                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_HI_BW                                = "
    tree.end
    tree "SMBCHGL_BAT_IF_ISENSE_CFG1"
      sgroup "SMBCHGL_BAT_IF_ISENSE_CFG1 (at 0x12fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_DCHG_G                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_DCHG_TEMP                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_BAT_IF_ISENSE_CFG2"
      sgroup "SMBCHGL_BAT_IF_ISENSE_CFG2 (at 0x12fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_CHG_G                             = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_CHG_TEMP                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHGL_BAT_IF_ZIN_ICL_PT"
      sgroup "SMBCHGL_BAT_IF_ZIN_ICL_PT (at 0x12fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_PT                               = "
    tree.end
    tree "SMBCHGL_BAT_IF_ZIN_ICL_LV"
      sgroup "SMBCHGL_BAT_IF_ZIN_ICL_LV (at 0x12fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_LV                               = "
    tree.end
    tree "SMBCHGL_BAT_IF_ZIN_ICL_HV"
      sgroup "SMBCHGL_BAT_IF_ZIN_ICL_HV (at 0x12fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_HV                               = "
    tree.end
    tree "SMBCHGL_BAT_IF_WI_PWR_TMR"
      sgroup "SMBCHGL_BAT_IF_WI_PWR_TMR (at 0x12ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DIV2_DG_SEL                              = " "0 (DIV2_DG_0US),1 (DIV2_DG_150US),2 (DIV2_DG_250US),3 (DIV2_DG_500US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WIPWR_IRQ_TMR                            = " "0 (WIPWR_IRQ_TMR_1P3S),1 (WIPWR_IRQ_TMR_1P95S),2 (WIPWR_IRQ_TMR_2P6S),3 (WIPWR_IRQ_TMR_3P25S),4 (WIPWR_IRQ_TMR_3P9S),5 (WIPWR_IRQ_TMR_4P55S),6 (WIPWR_IRQ_TMR_5P2S),7 (WIPWR_IRQ_TMR_5P85S)"
    tree.end
  tree.end
tree.end
tree "SMBCHGL_CHGR"
  tree "SMBCHGL_CHGR"
    tree "SMBCHGL_CHGR_PERPH_TYPE"
      sgroup "SMBCHGL_CHGR_PERPH_TYPE (at 0x1004)"
