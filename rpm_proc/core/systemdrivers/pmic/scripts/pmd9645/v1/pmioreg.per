entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BB_CLK1"
  tree "BB_CLK1"
    tree "BB_CLK1_REVISION1"
      sgroup "BB_CLK1_REVISION1 (at 0x5100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION2"
      sgroup "BB_CLK1_REVISION2 (at 0x5101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK1_REVISION3"
      sgroup "BB_CLK1_REVISION3 (at 0x5102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION4"
      sgroup "BB_CLK1_REVISION4 (at 0x5103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK1_PERPH_TYPE"
      sgroup "BB_CLK1_PERPH_TYPE (at 0x5104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK1_PERPH_SUBTYPE"
      sgroup "BB_CLK1_PERPH_SUBTYPE (at 0x5105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK1_STATUS1"
      sgroup "BB_CLK1_STATUS1 (at 0x5108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK1_EDGE_CTL1"
      sgroup "BB_CLK1_EDGE_CTL1 (at 0x5143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK1_DRV_CTL1"
      sgroup "BB_CLK1_DRV_CTL1 (at 0x5144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK1_EN_CTL"
      sgroup "BB_CLK1_EN_CTL (at 0x5146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK1_PD_CTL"
      sgroup "BB_CLK1_PD_CTL (at 0x5148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK1_SEC_ACCESS"
      sgroup "BB_CLK1_SEC_ACCESS (at 0x51d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL1"
      sgroup "BB_CLK1_PERPH_RESET_CTL1 (at 0x51d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL2"
      sgroup "BB_CLK1_PERPH_RESET_CTL2 (at 0x51d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL3"
      sgroup "BB_CLK1_PERPH_RESET_CTL3 (at 0x51da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL4"
      sgroup "BB_CLK1_PERPH_RESET_CTL4 (at 0x51db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      sgroup "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      sgroup "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      sgroup "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      sgroup "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      sgroup "BCLK_GEN_MAIN_STATUS (at 0x11008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      sgroup "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      sgroup "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      sgroup "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      sgroup "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      sgroup "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      sgroup "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      sgroup "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      sgroup "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      sgroup "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      sgroup "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      sgroup "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      sgroup "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      sgroup "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      sgroup "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      sgroup "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      sgroup "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      sgroup "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BUA_4UICC_DUAL_BATT_ALARM"
  tree "BUA_4UICC_DUAL_BATT_ALARM"
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION3"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION3 (at 0x1c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION4"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION4 (at 0x1c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_STATUS2 (at 0x1c09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS (at 0x1c10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE (at 0x1c11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH (at 0x1c12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW (at 0x1c13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR (at 0x1c14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET (at 0x1c15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR (at 0x1c16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS (at 0x1c18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS (at 0x1c19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL (at 0x1c1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY (at 0x1c1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_GONE_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2 (at 0x1c47)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BAT_GONE_COMP                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1 (at 0x1ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL (at 0x1ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_TEST1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST_SEL2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      sgroup "DIV_CLK1_REVISION1 (at 0x5b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      sgroup "DIV_CLK1_REVISION2 (at 0x5b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      sgroup "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      sgroup "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      sgroup "DIV_CLK1_STATUS1 (at 0x5b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      sgroup "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      sgroup "DIV_CLK1_EN_CTL (at 0x5b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      sgroup "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      sgroup "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      sgroup "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      sgroup "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      sgroup "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK2"
  tree "DIV_CLK2"
    tree "DIV_CLK2_REVISION1"
      sgroup "DIV_CLK2_REVISION1 (at 0x5c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK2_REVISION2"
      sgroup "DIV_CLK2_REVISION2 (at 0x5c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK2_PERPH_TYPE"
      sgroup "DIV_CLK2_PERPH_TYPE (at 0x5c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK2_PERPH_SUBTYPE"
      sgroup "DIV_CLK2_PERPH_SUBTYPE (at 0x5c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK2_STATUS1"
      sgroup "DIV_CLK2_STATUS1 (at 0x5c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK2_DIV_CTL1"
      sgroup "DIV_CLK2_DIV_CTL1 (at 0x5c43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK2_EN_CTL"
      sgroup "DIV_CLK2_EN_CTL (at 0x5c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK2_SEC_ACCESS"
      sgroup "DIV_CLK2_SEC_ACCESS (at 0x5cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL1"
      sgroup "DIV_CLK2_PERPH_RESET_CTL1 (at 0x5cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL2"
      sgroup "DIV_CLK2_PERPH_RESET_CTL2 (at 0x5cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL3"
      sgroup "DIV_CLK2_PERPH_RESET_CTL3 (at 0x5cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL4"
      sgroup "DIV_CLK2_PERPH_RESET_CTL4 (at 0x5cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK3"
  tree "DIV_CLK3"
    tree "DIV_CLK3_REVISION1"
      sgroup "DIV_CLK3_REVISION1 (at 0x5d00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK3_REVISION2"
      sgroup "DIV_CLK3_REVISION2 (at 0x5d01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK3_PERPH_TYPE"
      sgroup "DIV_CLK3_PERPH_TYPE (at 0x5d04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK3_PERPH_SUBTYPE"
      sgroup "DIV_CLK3_PERPH_SUBTYPE (at 0x5d05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK3_STATUS1"
      sgroup "DIV_CLK3_STATUS1 (at 0x5d08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK3_DIV_CTL1"
      sgroup "DIV_CLK3_DIV_CTL1 (at 0x5d43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK3_EN_CTL"
      sgroup "DIV_CLK3_EN_CTL (at 0x5d46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK3_SEC_ACCESS"
      sgroup "DIV_CLK3_SEC_ACCESS (at 0x5dd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL1"
      sgroup "DIV_CLK3_PERPH_RESET_CTL1 (at 0x5dd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL2"
      sgroup "DIV_CLK3_PERPH_RESET_CTL2 (at 0x5dd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL3"
      sgroup "DIV_CLK3_PERPH_RESET_CTL3 (at 0x5dda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL4"
      sgroup "DIV_CLK3_PERPH_RESET_CTL4 (at 0x5ddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      sgroup "GPIO1_DIG_IN_CTL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      sgroup "GPIO1_DIG_OUT_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      sgroup "GPIO2_DIG_IN_CTL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      sgroup "GPIO2_DIG_OUT_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      sgroup "GPIO3_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      sgroup "GPIO3_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      sgroup "GPIO3_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      sgroup "GPIO3_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      sgroup "GPIO3_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      sgroup "GPIO3_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      sgroup "GPIO3_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      sgroup "GPIO3_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      sgroup "GPIO3_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      sgroup "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      sgroup "GPIO3_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      sgroup "GPIO3_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      sgroup "GPIO3_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      sgroup "GPIO3_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      sgroup "GPIO3_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      sgroup "GPIO3_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      sgroup "GPIO3_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      sgroup "GPIO3_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      sgroup "GPIO3_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      sgroup "GPIO3_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      sgroup "GPIO3_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      sgroup "GPIO3_DIG_IN_CTL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      sgroup "GPIO3_DIG_OUT_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO3_EN_CTL"
      sgroup "GPIO3_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      sgroup "GPIO3_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      sgroup "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      sgroup "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      sgroup "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      sgroup "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      sgroup "GPIO4_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      sgroup "GPIO4_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      sgroup "GPIO4_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      sgroup "GPIO4_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      sgroup "GPIO4_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      sgroup "GPIO4_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      sgroup "GPIO4_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      sgroup "GPIO4_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      sgroup "GPIO4_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      sgroup "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      sgroup "GPIO4_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      sgroup "GPIO4_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      sgroup "GPIO4_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      sgroup "GPIO4_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      sgroup "GPIO4_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      sgroup "GPIO4_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      sgroup "GPIO4_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      sgroup "GPIO4_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      sgroup "GPIO4_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      sgroup "GPIO4_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      sgroup "GPIO4_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      sgroup "GPIO4_DIG_IN_CTL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      sgroup "GPIO4_DIG_OUT_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO4_EN_CTL"
      sgroup "GPIO4_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      sgroup "GPIO4_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      sgroup "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      sgroup "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      sgroup "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      sgroup "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO5"
  tree "GPIO5"
    tree "GPIO5_REVISION1"
      sgroup "GPIO5_REVISION1 (at 0xc400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION2"
      sgroup "GPIO5_REVISION2 (at 0xc401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO5_REVISION3"
      sgroup "GPIO5_REVISION3 (at 0xc402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION4"
      sgroup "GPIO5_REVISION4 (at 0xc403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO5_PERPH_TYPE"
      sgroup "GPIO5_PERPH_TYPE (at 0xc404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO5_PERPH_SUBTYPE"
      sgroup "GPIO5_PERPH_SUBTYPE (at 0xc405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO5_STATUS1"
      sgroup "GPIO5_STATUS1 (at 0xc408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO5_INT_RT_STS"
      sgroup "GPIO5_INT_RT_STS (at 0xc410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO5_INT_SET_TYPE"
      sgroup "GPIO5_INT_SET_TYPE (at 0xc411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO5_INT_POLARITY_HIGH"
      sgroup "GPIO5_INT_POLARITY_HIGH (at 0xc412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_POLARITY_LOW"
      sgroup "GPIO5_INT_POLARITY_LOW (at 0xc413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_CLR"
      sgroup "GPIO5_INT_LATCHED_CLR (at 0xc414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_SET"
      sgroup "GPIO5_INT_EN_SET (at 0xc415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_EN_CLR"
      sgroup "GPIO5_INT_EN_CLR (at 0xc416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_STS"
      sgroup "GPIO5_INT_LATCHED_STS (at 0xc418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO5_INT_PENDING_STS"
      sgroup "GPIO5_INT_PENDING_STS (at 0xc419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO5_INT_MID_SEL"
      sgroup "GPIO5_INT_MID_SEL (at 0xc41a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO5_INT_PRIORITY"
      sgroup "GPIO5_INT_PRIORITY (at 0xc41b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO5_MODE_CTL"
      sgroup "GPIO5_MODE_CTL (at 0xc440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO5_DIG_VIN_CTL"
      sgroup "GPIO5_DIG_VIN_CTL (at 0xc441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO5_DIG_PULL_CTL"
      sgroup "GPIO5_DIG_PULL_CTL (at 0xc442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO5_DIG_IN_CTL"
      sgroup "GPIO5_DIG_IN_CTL (at 0xc443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO5_DIG_OUT_CTL"
      sgroup "GPIO5_DIG_OUT_CTL (at 0xc445)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO5_EN_CTL"
      sgroup "GPIO5_EN_CTL (at 0xc446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO5_SEC_ACCESS"
      sgroup "GPIO5_SEC_ACCESS (at 0xc4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO5_PERPH_RESET_CTL1"
      sgroup "GPIO5_PERPH_RESET_CTL1 (at 0xc4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL2"
      sgroup "GPIO5_PERPH_RESET_CTL2 (at 0xc4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL3"
      sgroup "GPIO5_PERPH_RESET_CTL3 (at 0xc4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL4"
      sgroup "GPIO5_PERPH_RESET_CTL4 (at 0xc4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO6"
  tree "GPIO6"
    tree "GPIO6_REVISION1"
      sgroup "GPIO6_REVISION1 (at 0xc500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION2"
      sgroup "GPIO6_REVISION2 (at 0xc501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO6_REVISION3"
      sgroup "GPIO6_REVISION3 (at 0xc502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION4"
      sgroup "GPIO6_REVISION4 (at 0xc503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO6_PERPH_TYPE"
      sgroup "GPIO6_PERPH_TYPE (at 0xc504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO6_PERPH_SUBTYPE"
      sgroup "GPIO6_PERPH_SUBTYPE (at 0xc505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO6_STATUS1"
      sgroup "GPIO6_STATUS1 (at 0xc508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO6_INT_RT_STS"
      sgroup "GPIO6_INT_RT_STS (at 0xc510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO6_INT_SET_TYPE"
      sgroup "GPIO6_INT_SET_TYPE (at 0xc511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO6_INT_POLARITY_HIGH"
      sgroup "GPIO6_INT_POLARITY_HIGH (at 0xc512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_POLARITY_LOW"
      sgroup "GPIO6_INT_POLARITY_LOW (at 0xc513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_CLR"
      sgroup "GPIO6_INT_LATCHED_CLR (at 0xc514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_SET"
      sgroup "GPIO6_INT_EN_SET (at 0xc515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_EN_CLR"
      sgroup "GPIO6_INT_EN_CLR (at 0xc516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_STS"
      sgroup "GPIO6_INT_LATCHED_STS (at 0xc518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO6_INT_PENDING_STS"
      sgroup "GPIO6_INT_PENDING_STS (at 0xc519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO6_INT_MID_SEL"
      sgroup "GPIO6_INT_MID_SEL (at 0xc51a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO6_INT_PRIORITY"
      sgroup "GPIO6_INT_PRIORITY (at 0xc51b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO6_MODE_CTL"
      sgroup "GPIO6_MODE_CTL (at 0xc540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO6_DIG_VIN_CTL"
      sgroup "GPIO6_DIG_VIN_CTL (at 0xc541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO6_DIG_PULL_CTL"
      sgroup "GPIO6_DIG_PULL_CTL (at 0xc542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO6_DIG_IN_CTL"
      sgroup "GPIO6_DIG_IN_CTL (at 0xc543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO6_DIG_OUT_CTL"
      sgroup "GPIO6_DIG_OUT_CTL (at 0xc545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO6_EN_CTL"
      sgroup "GPIO6_EN_CTL (at 0xc546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO6_SEC_ACCESS"
      sgroup "GPIO6_SEC_ACCESS (at 0xc5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO6_PERPH_RESET_CTL1"
      sgroup "GPIO6_PERPH_RESET_CTL1 (at 0xc5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL2"
      sgroup "GPIO6_PERPH_RESET_CTL2 (at 0xc5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL3"
      sgroup "GPIO6_PERPH_RESET_CTL3 (at 0xc5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL4"
      sgroup "GPIO6_PERPH_RESET_CTL4 (at 0xc5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      sgroup "LDO1_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      sgroup "LDO1_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      sgroup "LDO1_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      sgroup "LDO1_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      sgroup "LDO1_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      sgroup "LDO1_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      sgroup "LDO1_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO1_STATUS2"
      sgroup "LDO1_STATUS2 (at 0x14009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      sgroup "LDO1_STATUS3 (at 0x1400a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      sgroup "LDO1_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      sgroup "LDO1_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      sgroup "LDO1_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      sgroup "LDO1_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      sgroup "LDO1_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      sgroup "LDO1_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      sgroup "LDO1_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      sgroup "LDO1_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      sgroup "LDO1_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      sgroup "LDO1_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      sgroup "LDO1_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      sgroup "LDO1_VOLTAGE_CTL1 (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      sgroup "LDO1_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      sgroup "LDO1_MODE_CTL2 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      sgroup "LDO1_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      sgroup "LDO1_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      sgroup "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      sgroup "LDO1_SOFT_START_CTL (at 0x1404c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      sgroup "LDO1_CONFIG_CTL (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      sgroup "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      sgroup "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      sgroup "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      sgroup "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      sgroup "LDO1_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      sgroup "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      sgroup "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      sgroup "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      sgroup "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      sgroup "LDO1_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      sgroup "LDO1_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      sgroup "LDO1_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      sgroup "LDO1_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      sgroup "LDO1_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      sgroup "LDO1_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      sgroup "LDO10_REVISION1 (at 0x14900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      sgroup "LDO10_REVISION2 (at 0x14901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      sgroup "LDO10_REVISION3 (at 0x14902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      sgroup "LDO10_REVISION4 (at 0x14903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      sgroup "LDO10_PERPH_TYPE (at 0x14904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      sgroup "LDO10_PERPH_SUBTYPE (at 0x14905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      sgroup "LDO10_STATUS1 (at 0x14908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO10_STATUS2"
      sgroup "LDO10_STATUS2 (at 0x14909)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO10_STATUS3"
      sgroup "LDO10_STATUS3 (at 0x1490a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80490a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x490a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO10_INT_RT_STS"
      sgroup "LDO10_INT_RT_STS (at 0x14910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      sgroup "LDO10_INT_SET_TYPE (at 0x14911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      sgroup "LDO10_INT_POLARITY_HIGH (at 0x14912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      sgroup "LDO10_INT_POLARITY_LOW (at 0x14913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      sgroup "LDO10_INT_LATCHED_CLR (at 0x14914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO10_INT_EN_SET"
      sgroup "LDO10_INT_EN_SET (at 0x14915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_EN_CLR"
      sgroup "LDO10_INT_EN_CLR (at 0x14916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      sgroup "LDO10_INT_LATCHED_STS (at 0x14918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      sgroup "LDO10_INT_PENDING_STS (at 0x14919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_MID_SEL"
      sgroup "LDO10_INT_MID_SEL (at 0x1491a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO10_INT_PRIORITY"
      sgroup "LDO10_INT_PRIORITY (at 0x1491b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO10_VOLTAGE_CTL1"
      sgroup "LDO10_VOLTAGE_CTL1 (at 0x14940)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_VOLTAGE_CTL2"
      sgroup "LDO10_VOLTAGE_CTL2 (at 0x14941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO10_MODE_CTL2"
      sgroup "LDO10_MODE_CTL2 (at 0x14945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_EN_CTL"
      sgroup "LDO10_EN_CTL (at 0x14946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_PD_CTL"
      sgroup "LDO10_PD_CTL (at 0x14948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO10_CURRENT_LIM_CTL"
      sgroup "LDO10_CURRENT_LIM_CTL (at 0x1494a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80494a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x494a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO10_SOFT_START_CTL"
      sgroup "LDO10_SOFT_START_CTL (at 0x1494c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80494c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x494c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO10_CONFIG_CTL"
      sgroup "LDO10_CONFIG_CTL (at 0x14952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL1"
      sgroup "LDO10_LL_VOLTAGE_CTL1 (at 0x14968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL2"
      sgroup "LDO10_LL_VOLTAGE_CTL2 (at 0x14969)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL1"
      sgroup "LDO10_UL_VOLTAGE_CTL1 (at 0x1496a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80496a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x496a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL2"
      sgroup "LDO10_UL_VOLTAGE_CTL2 (at 0x1496b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80496b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x496b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO10_SEC_ACCESS"
      sgroup "LDO10_SEC_ACCESS (at 0x149d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      sgroup "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      sgroup "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      sgroup "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      sgroup "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO10_INT_TEST1"
      sgroup "LDO10_INT_TEST1 (at 0x149e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      sgroup "LDO10_INT_TEST_VAL (at 0x149e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO10_TEST1"
      sgroup "LDO10_TEST1 (at 0x149e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      sgroup "LDO10_TEST2 (at 0x149e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO10_TRIM_NUM"
      sgroup "LDO10_TRIM_NUM (at 0x149f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      sgroup "LDO10_TRIM_CTRL (at 0x149f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      sgroup "LDO11_REVISION1 (at 0x14a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      sgroup "LDO11_REVISION2 (at 0x14a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      sgroup "LDO11_REVISION3 (at 0x14a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      sgroup "LDO11_REVISION4 (at 0x14a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      sgroup "LDO11_PERPH_TYPE (at 0x14a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      sgroup "LDO11_PERPH_SUBTYPE (at 0x14a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      sgroup "LDO11_STATUS1 (at 0x14a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO11_STATUS2"
      sgroup "LDO11_STATUS2 (at 0x14a09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO11_STATUS3"
      sgroup "LDO11_STATUS3 (at 0x14a0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO11_INT_RT_STS"
      sgroup "LDO11_INT_RT_STS (at 0x14a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_SET_TYPE"
      sgroup "LDO11_INT_SET_TYPE (at 0x14a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_HIGH"
      sgroup "LDO11_INT_POLARITY_HIGH (at 0x14a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_LOW"
      sgroup "LDO11_INT_POLARITY_LOW (at 0x14a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO11_INT_LATCHED_CLR"
      sgroup "LDO11_INT_LATCHED_CLR (at 0x14a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO11_INT_EN_SET"
      sgroup "LDO11_INT_EN_SET (at 0x14a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_EN_CLR"
      sgroup "LDO11_INT_EN_CLR (at 0x14a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_LATCHED_STS"
      sgroup "LDO11_INT_LATCHED_STS (at 0x14a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO11_INT_PENDING_STS"
      sgroup "LDO11_INT_PENDING_STS (at 0x14a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_MID_SEL"
      sgroup "LDO11_INT_MID_SEL (at 0x14a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO11_INT_PRIORITY"
      sgroup "LDO11_INT_PRIORITY (at 0x14a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO11_VOLTAGE_CTL1"
      sgroup "LDO11_VOLTAGE_CTL1 (at 0x14a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_VOLTAGE_CTL2"
      sgroup "LDO11_VOLTAGE_CTL2 (at 0x14a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO11_MODE_CTL2"
      sgroup "LDO11_MODE_CTL2 (at 0x14a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_EN_CTL"
      sgroup "LDO11_EN_CTL (at 0x14a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_PD_CTL"
      sgroup "LDO11_PD_CTL (at 0x14a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO11_CURRENT_LIM_CTL"
      sgroup "LDO11_CURRENT_LIM_CTL (at 0x14a4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO11_SOFT_START_CTL"
      sgroup "LDO11_SOFT_START_CTL (at 0x14a4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO11_CONFIG_CTL"
      sgroup "LDO11_CONFIG_CTL (at 0x14a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL1"
      sgroup "LDO11_LL_VOLTAGE_CTL1 (at 0x14a68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL2"
      sgroup "LDO11_LL_VOLTAGE_CTL2 (at 0x14a69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL1"
      sgroup "LDO11_UL_VOLTAGE_CTL1 (at 0x14a6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL2"
      sgroup "LDO11_UL_VOLTAGE_CTL2 (at 0x14a6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO11_SEC_ACCESS"
      sgroup "LDO11_SEC_ACCESS (at 0x14ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      sgroup "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      sgroup "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      sgroup "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      sgroup "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO11_INT_TEST1"
      sgroup "LDO11_INT_TEST1 (at 0x14ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO11_INT_TEST_VAL"
      sgroup "LDO11_INT_TEST_VAL (at 0x14ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO11_TEST1"
      sgroup "LDO11_TEST1 (at 0x14ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO11_TEST2"
      sgroup "LDO11_TEST2 (at 0x14ae3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO11_TRIM_NUM"
      sgroup "LDO11_TRIM_NUM (at 0x14af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO11_TRIM_CTRL"
      sgroup "LDO11_TRIM_CTRL (at 0x14af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      sgroup "LDO12_REVISION1 (at 0x14b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      sgroup "LDO12_REVISION2 (at 0x14b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      sgroup "LDO12_REVISION3 (at 0x14b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      sgroup "LDO12_REVISION4 (at 0x14b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      sgroup "LDO12_PERPH_TYPE (at 0x14b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      sgroup "LDO12_PERPH_SUBTYPE (at 0x14b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      sgroup "LDO12_STATUS1 (at 0x14b08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO12_STATUS2"
      sgroup "LDO12_STATUS2 (at 0x14b09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO12_STATUS3"
      sgroup "LDO12_STATUS3 (at 0x14b0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO12_INT_RT_STS"
      sgroup "LDO12_INT_RT_STS (at 0x14b10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      sgroup "LDO12_INT_SET_TYPE (at 0x14b11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      sgroup "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      sgroup "LDO12_INT_POLARITY_LOW (at 0x14b13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      sgroup "LDO12_INT_LATCHED_CLR (at 0x14b14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO12_INT_EN_SET"
      sgroup "LDO12_INT_EN_SET (at 0x14b15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_EN_CLR"
      sgroup "LDO12_INT_EN_CLR (at 0x14b16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      sgroup "LDO12_INT_LATCHED_STS (at 0x14b18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      sgroup "LDO12_INT_PENDING_STS (at 0x14b19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_MID_SEL"
      sgroup "LDO12_INT_MID_SEL (at 0x14b1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO12_INT_PRIORITY"
      sgroup "LDO12_INT_PRIORITY (at 0x14b1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO12_VOLTAGE_CTL1"
      sgroup "LDO12_VOLTAGE_CTL1 (at 0x14b40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_VOLTAGE_CTL2"
      sgroup "LDO12_VOLTAGE_CTL2 (at 0x14b41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO12_MODE_CTL2"
      sgroup "LDO12_MODE_CTL2 (at 0x14b45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_EN_CTL"
      sgroup "LDO12_EN_CTL (at 0x14b46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_PD_CTL"
      sgroup "LDO12_PD_CTL (at 0x14b48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO12_CURRENT_LIM_CTL"
      sgroup "LDO12_CURRENT_LIM_CTL (at 0x14b4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO12_SOFT_START_CTL"
      sgroup "LDO12_SOFT_START_CTL (at 0x14b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO12_CONFIG_CTL"
      sgroup "LDO12_CONFIG_CTL (at 0x14b52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL1"
      sgroup "LDO12_LL_VOLTAGE_CTL1 (at 0x14b68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL2"
      sgroup "LDO12_LL_VOLTAGE_CTL2 (at 0x14b69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL1"
      sgroup "LDO12_UL_VOLTAGE_CTL1 (at 0x14b6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL2"
      sgroup "LDO12_UL_VOLTAGE_CTL2 (at 0x14b6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO12_SEC_ACCESS"
      sgroup "LDO12_SEC_ACCESS (at 0x14bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      sgroup "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      sgroup "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      sgroup "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      sgroup "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO12_INT_TEST1"
      sgroup "LDO12_INT_TEST1 (at 0x14be0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      sgroup "LDO12_INT_TEST_VAL (at 0x14be1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO12_TEST1"
      sgroup "LDO12_TEST1 (at 0x14be2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      sgroup "LDO12_TEST2 (at 0x14be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO12_TRIM_NUM"
      sgroup "LDO12_TRIM_NUM (at 0x14bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      sgroup "LDO12_TRIM_CTRL (at 0x14bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      sgroup "LDO13_REVISION1 (at 0x14c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      sgroup "LDO13_REVISION2 (at 0x14c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      sgroup "LDO13_REVISION3 (at 0x14c02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      sgroup "LDO13_REVISION4 (at 0x14c03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      sgroup "LDO13_PERPH_TYPE (at 0x14c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      sgroup "LDO13_PERPH_SUBTYPE (at 0x14c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      sgroup "LDO13_STATUS1 (at 0x14c08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO13_STATUS2"
      sgroup "LDO13_STATUS2 (at 0x14c09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO13_STATUS3"
      sgroup "LDO13_STATUS3 (at 0x14c0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO13_INT_RT_STS"
      sgroup "LDO13_INT_RT_STS (at 0x14c10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_SET_TYPE"
      sgroup "LDO13_INT_SET_TYPE (at 0x14c11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_HIGH"
      sgroup "LDO13_INT_POLARITY_HIGH (at 0x14c12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_LOW"
      sgroup "LDO13_INT_POLARITY_LOW (at 0x14c13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO13_INT_LATCHED_CLR"
      sgroup "LDO13_INT_LATCHED_CLR (at 0x14c14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO13_INT_EN_SET"
      sgroup "LDO13_INT_EN_SET (at 0x14c15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_EN_CLR"
      sgroup "LDO13_INT_EN_CLR (at 0x14c16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_LATCHED_STS"
      sgroup "LDO13_INT_LATCHED_STS (at 0x14c18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO13_INT_PENDING_STS"
      sgroup "LDO13_INT_PENDING_STS (at 0x14c19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_MID_SEL"
      sgroup "LDO13_INT_MID_SEL (at 0x14c1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO13_INT_PRIORITY"
      sgroup "LDO13_INT_PRIORITY (at 0x14c1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO13_VOLTAGE_CTL1"
      sgroup "LDO13_VOLTAGE_CTL1 (at 0x14c40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_VOLTAGE_CTL2"
      sgroup "LDO13_VOLTAGE_CTL2 (at 0x14c41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO13_MODE_CTL2"
      sgroup "LDO13_MODE_CTL2 (at 0x14c45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_EN_CTL"
      sgroup "LDO13_EN_CTL (at 0x14c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_PD_CTL"
      sgroup "LDO13_PD_CTL (at 0x14c48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO13_CURRENT_LIM_CTL"
      sgroup "LDO13_CURRENT_LIM_CTL (at 0x14c4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO13_SOFT_START_CTL"
      sgroup "LDO13_SOFT_START_CTL (at 0x14c4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO13_CONFIG_CTL"
      sgroup "LDO13_CONFIG_CTL (at 0x14c52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL1"
      sgroup "LDO13_LL_VOLTAGE_CTL1 (at 0x14c68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL2"
      sgroup "LDO13_LL_VOLTAGE_CTL2 (at 0x14c69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL1"
      sgroup "LDO13_UL_VOLTAGE_CTL1 (at 0x14c6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL2"
      sgroup "LDO13_UL_VOLTAGE_CTL2 (at 0x14c6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO13_SEC_ACCESS"
      sgroup "LDO13_SEC_ACCESS (at 0x14cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      sgroup "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      sgroup "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      sgroup "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      sgroup "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO13_INT_TEST1"
      sgroup "LDO13_INT_TEST1 (at 0x14ce0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO13_INT_TEST_VAL"
      sgroup "LDO13_INT_TEST_VAL (at 0x14ce1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO13_TEST1"
      sgroup "LDO13_TEST1 (at 0x14ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO13_TEST2"
      sgroup "LDO13_TEST2 (at 0x14ce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO13_TRIM_NUM"
      sgroup "LDO13_TRIM_NUM (at 0x14cf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO13_TRIM_CTRL"
      sgroup "LDO13_TRIM_CTRL (at 0x14cf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO14"
  tree "LDO14"
    tree "LDO14_REVISION1"
      sgroup "LDO14_REVISION1 (at 0x14d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO14_REVISION2"
      sgroup "LDO14_REVISION2 (at 0x14d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO14_REVISION3"
      sgroup "LDO14_REVISION3 (at 0x14d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO14_REVISION4"
      sgroup "LDO14_REVISION4 (at 0x14d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO14_PERPH_TYPE"
      sgroup "LDO14_PERPH_TYPE (at 0x14d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO14_PERPH_SUBTYPE"
      sgroup "LDO14_PERPH_SUBTYPE (at 0x14d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO14_STATUS1"
      sgroup "LDO14_STATUS1 (at 0x14d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO14_STATUS2"
      sgroup "LDO14_STATUS2 (at 0x14d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO14_STATUS3"
      sgroup "LDO14_STATUS3 (at 0x14d0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO14_INT_RT_STS"
      sgroup "LDO14_INT_RT_STS (at 0x14d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_SET_TYPE"
      sgroup "LDO14_INT_SET_TYPE (at 0x14d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_HIGH"
      sgroup "LDO14_INT_POLARITY_HIGH (at 0x14d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_LOW"
      sgroup "LDO14_INT_POLARITY_LOW (at 0x14d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO14_INT_LATCHED_CLR"
      sgroup "LDO14_INT_LATCHED_CLR (at 0x14d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO14_INT_EN_SET"
      sgroup "LDO14_INT_EN_SET (at 0x14d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_EN_CLR"
      sgroup "LDO14_INT_EN_CLR (at 0x14d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_LATCHED_STS"
      sgroup "LDO14_INT_LATCHED_STS (at 0x14d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO14_INT_PENDING_STS"
      sgroup "LDO14_INT_PENDING_STS (at 0x14d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_MID_SEL"
      sgroup "LDO14_INT_MID_SEL (at 0x14d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO14_INT_PRIORITY"
      sgroup "LDO14_INT_PRIORITY (at 0x14d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO14_VOLTAGE_CTL1"
      sgroup "LDO14_VOLTAGE_CTL1 (at 0x14d40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_VOLTAGE_CTL2"
      sgroup "LDO14_VOLTAGE_CTL2 (at 0x14d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO14_MODE_CTL2"
      sgroup "LDO14_MODE_CTL2 (at 0x14d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_EN_CTL"
      sgroup "LDO14_EN_CTL (at 0x14d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_PD_CTL"
      sgroup "LDO14_PD_CTL (at 0x14d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO14_CURRENT_LIM_CTL"
      sgroup "LDO14_CURRENT_LIM_CTL (at 0x14d4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO14_SOFT_START_CTL"
      sgroup "LDO14_SOFT_START_CTL (at 0x14d4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO14_CONFIG_CTL"
      sgroup "LDO14_CONFIG_CTL (at 0x14d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL1"
      sgroup "LDO14_LL_VOLTAGE_CTL1 (at 0x14d68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL2"
      sgroup "LDO14_LL_VOLTAGE_CTL2 (at 0x14d69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL1"
      sgroup "LDO14_UL_VOLTAGE_CTL1 (at 0x14d6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL2"
      sgroup "LDO14_UL_VOLTAGE_CTL2 (at 0x14d6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO14_SEC_ACCESS"
      sgroup "LDO14_SEC_ACCESS (at 0x14dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO14_PERPH_RESET_CTL1"
      sgroup "LDO14_PERPH_RESET_CTL1 (at 0x14dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL2"
      sgroup "LDO14_PERPH_RESET_CTL2 (at 0x14dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL3"
      sgroup "LDO14_PERPH_RESET_CTL3 (at 0x14dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL4"
      sgroup "LDO14_PERPH_RESET_CTL4 (at 0x14ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO14_INT_TEST1"
      sgroup "LDO14_INT_TEST1 (at 0x14de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO14_INT_TEST_VAL"
      sgroup "LDO14_INT_TEST_VAL (at 0x14de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO14_TEST1"
      sgroup "LDO14_TEST1 (at 0x14de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO14_TEST2"
      sgroup "LDO14_TEST2 (at 0x14de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO14_TRIM_NUM"
      sgroup "LDO14_TRIM_NUM (at 0x14df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO14_TRIM_CTRL"
      sgroup "LDO14_TRIM_CTRL (at 0x14df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO15"
  tree "LDO15"
    tree "LDO15_REVISION1"
      sgroup "LDO15_REVISION1 (at 0x14e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO15_REVISION2"
      sgroup "LDO15_REVISION2 (at 0x14e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO15_REVISION3"
      sgroup "LDO15_REVISION3 (at 0x14e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO15_REVISION4"
      sgroup "LDO15_REVISION4 (at 0x14e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO15_PERPH_TYPE"
      sgroup "LDO15_PERPH_TYPE (at 0x14e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO15_PERPH_SUBTYPE"
      sgroup "LDO15_PERPH_SUBTYPE (at 0x14e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO15_STATUS1"
      sgroup "LDO15_STATUS1 (at 0x14e08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO15_STATUS2"
      sgroup "LDO15_STATUS2 (at 0x14e09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO15_STATUS3"
      sgroup "LDO15_STATUS3 (at 0x14e0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO15_INT_RT_STS"
      sgroup "LDO15_INT_RT_STS (at 0x14e10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_SET_TYPE"
      sgroup "LDO15_INT_SET_TYPE (at 0x14e11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_HIGH"
      sgroup "LDO15_INT_POLARITY_HIGH (at 0x14e12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_LOW"
      sgroup "LDO15_INT_POLARITY_LOW (at 0x14e13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO15_INT_LATCHED_CLR"
      sgroup "LDO15_INT_LATCHED_CLR (at 0x14e14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO15_INT_EN_SET"
      sgroup "LDO15_INT_EN_SET (at 0x14e15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_EN_CLR"
      sgroup "LDO15_INT_EN_CLR (at 0x14e16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_LATCHED_STS"
      sgroup "LDO15_INT_LATCHED_STS (at 0x14e18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO15_INT_PENDING_STS"
      sgroup "LDO15_INT_PENDING_STS (at 0x14e19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_MID_SEL"
      sgroup "LDO15_INT_MID_SEL (at 0x14e1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO15_INT_PRIORITY"
      sgroup "LDO15_INT_PRIORITY (at 0x14e1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO15_VOLTAGE_CTL1"
      sgroup "LDO15_VOLTAGE_CTL1 (at 0x14e40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_VOLTAGE_CTL2"
      sgroup "LDO15_VOLTAGE_CTL2 (at 0x14e41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO15_MODE_CTL2"
      sgroup "LDO15_MODE_CTL2 (at 0x14e45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_EN_CTL"
      sgroup "LDO15_EN_CTL (at 0x14e46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_PD_CTL"
      sgroup "LDO15_PD_CTL (at 0x14e48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO15_CURRENT_LIM_CTL"
      sgroup "LDO15_CURRENT_LIM_CTL (at 0x14e4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO15_SOFT_START_CTL"
      sgroup "LDO15_SOFT_START_CTL (at 0x14e4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO15_CONFIG_CTL"
      sgroup "LDO15_CONFIG_CTL (at 0x14e52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL1"
      sgroup "LDO15_LL_VOLTAGE_CTL1 (at 0x14e68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL2"
      sgroup "LDO15_LL_VOLTAGE_CTL2 (at 0x14e69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL1"
      sgroup "LDO15_UL_VOLTAGE_CTL1 (at 0x14e6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL2"
      sgroup "LDO15_UL_VOLTAGE_CTL2 (at 0x14e6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO15_SEC_ACCESS"
      sgroup "LDO15_SEC_ACCESS (at 0x14ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO15_PERPH_RESET_CTL1"
      sgroup "LDO15_PERPH_RESET_CTL1 (at 0x14ed8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL2"
      sgroup "LDO15_PERPH_RESET_CTL2 (at 0x14ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL3"
      sgroup "LDO15_PERPH_RESET_CTL3 (at 0x14eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL4"
      sgroup "LDO15_PERPH_RESET_CTL4 (at 0x14edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO15_INT_TEST1"
      sgroup "LDO15_INT_TEST1 (at 0x14ee0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO15_INT_TEST_VAL"
      sgroup "LDO15_INT_TEST_VAL (at 0x14ee1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO15_TEST1"
      sgroup "LDO15_TEST1 (at 0x14ee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO15_TEST2"
      sgroup "LDO15_TEST2 (at 0x14ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO15_TRIM_NUM"
      sgroup "LDO15_TRIM_NUM (at 0x14ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO15_TRIM_CTRL"
      sgroup "LDO15_TRIM_CTRL (at 0x14ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO16"
  tree "LDO16"
    tree "LDO16_REVISION1"
      sgroup "LDO16_REVISION1 (at 0x14f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO16_REVISION2"
      sgroup "LDO16_REVISION2 (at 0x14f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO16_REVISION3"
      sgroup "LDO16_REVISION3 (at 0x14f02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO16_REVISION4"
      sgroup "LDO16_REVISION4 (at 0x14f03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO16_PERPH_TYPE"
      sgroup "LDO16_PERPH_TYPE (at 0x14f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO16_PERPH_SUBTYPE"
      sgroup "LDO16_PERPH_SUBTYPE (at 0x14f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO16_STATUS1"
      sgroup "LDO16_STATUS1 (at 0x14f08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO16_STATUS2"
      sgroup "LDO16_STATUS2 (at 0x14f09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO16_STATUS3"
      sgroup "LDO16_STATUS3 (at 0x14f0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO16_INT_RT_STS"
      sgroup "LDO16_INT_RT_STS (at 0x14f10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_SET_TYPE"
      sgroup "LDO16_INT_SET_TYPE (at 0x14f11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_HIGH"
      sgroup "LDO16_INT_POLARITY_HIGH (at 0x14f12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_LOW"
      sgroup "LDO16_INT_POLARITY_LOW (at 0x14f13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO16_INT_LATCHED_CLR"
      sgroup "LDO16_INT_LATCHED_CLR (at 0x14f14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO16_INT_EN_SET"
      sgroup "LDO16_INT_EN_SET (at 0x14f15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_EN_CLR"
      sgroup "LDO16_INT_EN_CLR (at 0x14f16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_LATCHED_STS"
      sgroup "LDO16_INT_LATCHED_STS (at 0x14f18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO16_INT_PENDING_STS"
      sgroup "LDO16_INT_PENDING_STS (at 0x14f19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_MID_SEL"
      sgroup "LDO16_INT_MID_SEL (at 0x14f1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO16_INT_PRIORITY"
      sgroup "LDO16_INT_PRIORITY (at 0x14f1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO16_VOLTAGE_CTL1"
      sgroup "LDO16_VOLTAGE_CTL1 (at 0x14f40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_VOLTAGE_CTL2"
      sgroup "LDO16_VOLTAGE_CTL2 (at 0x14f41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO16_MODE_CTL2"
      sgroup "LDO16_MODE_CTL2 (at 0x14f45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_EN_CTL"
      sgroup "LDO16_EN_CTL (at 0x14f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_PD_CTL"
      sgroup "LDO16_PD_CTL (at 0x14f48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO16_CURRENT_LIM_CTL"
      sgroup "LDO16_CURRENT_LIM_CTL (at 0x14f4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO16_SOFT_START_CTL"
      sgroup "LDO16_SOFT_START_CTL (at 0x14f4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO16_CONFIG_CTL"
      sgroup "LDO16_CONFIG_CTL (at 0x14f52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL1"
      sgroup "LDO16_LL_VOLTAGE_CTL1 (at 0x14f68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL2"
      sgroup "LDO16_LL_VOLTAGE_CTL2 (at 0x14f69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL1"
      sgroup "LDO16_UL_VOLTAGE_CTL1 (at 0x14f6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL2"
      sgroup "LDO16_UL_VOLTAGE_CTL2 (at 0x14f6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO16_SEC_ACCESS"
      sgroup "LDO16_SEC_ACCESS (at 0x14fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO16_PERPH_RESET_CTL1"
      sgroup "LDO16_PERPH_RESET_CTL1 (at 0x14fd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL2"
      sgroup "LDO16_PERPH_RESET_CTL2 (at 0x14fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL3"
      sgroup "LDO16_PERPH_RESET_CTL3 (at 0x14fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL4"
      sgroup "LDO16_PERPH_RESET_CTL4 (at 0x14fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO16_INT_TEST1"
      sgroup "LDO16_INT_TEST1 (at 0x14fe0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO16_INT_TEST_VAL"
      sgroup "LDO16_INT_TEST_VAL (at 0x14fe1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO16_TEST1"
      sgroup "LDO16_TEST1 (at 0x14fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO16_TEST2"
      sgroup "LDO16_TEST2 (at 0x14fe3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO16_TRIM_NUM"
      sgroup "LDO16_TRIM_NUM (at 0x14ff0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO16_TRIM_CTRL"
      sgroup "LDO16_TRIM_CTRL (at 0x14ff1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO2"
  tree "LDO2"
    tree "LDO2_REVISION1"
      sgroup "LDO2_REVISION1 (at 0x14100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO2_REVISION2"
      sgroup "LDO2_REVISION2 (at 0x14101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO2_REVISION3"
      sgroup "LDO2_REVISION3 (at 0x14102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO2_REVISION4"
      sgroup "LDO2_REVISION4 (at 0x14103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO2_PERPH_TYPE"
      sgroup "LDO2_PERPH_TYPE (at 0x14104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO2_PERPH_SUBTYPE"
      sgroup "LDO2_PERPH_SUBTYPE (at 0x14105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO2_STATUS1"
      sgroup "LDO2_STATUS1 (at 0x14108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO2_STATUS2"
      sgroup "LDO2_STATUS2 (at 0x14109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO2_STATUS3"
      sgroup "LDO2_STATUS3 (at 0x1410a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80410a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO2_INT_RT_STS"
      sgroup "LDO2_INT_RT_STS (at 0x14110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_SET_TYPE"
      sgroup "LDO2_INT_SET_TYPE (at 0x14111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_HIGH"
      sgroup "LDO2_INT_POLARITY_HIGH (at 0x14112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_LOW"
      sgroup "LDO2_INT_POLARITY_LOW (at 0x14113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO2_INT_LATCHED_CLR"
      sgroup "LDO2_INT_LATCHED_CLR (at 0x14114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO2_INT_EN_SET"
      sgroup "LDO2_INT_EN_SET (at 0x14115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_EN_CLR"
      sgroup "LDO2_INT_EN_CLR (at 0x14116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_LATCHED_STS"
      sgroup "LDO2_INT_LATCHED_STS (at 0x14118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO2_INT_PENDING_STS"
      sgroup "LDO2_INT_PENDING_STS (at 0x14119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_MID_SEL"
      sgroup "LDO2_INT_MID_SEL (at 0x1411a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO2_INT_PRIORITY"
      sgroup "LDO2_INT_PRIORITY (at 0x1411b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO2_VOLTAGE_CTL1"
      sgroup "LDO2_VOLTAGE_CTL1 (at 0x14140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_VOLTAGE_CTL2"
      sgroup "LDO2_VOLTAGE_CTL2 (at 0x14141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO2_MODE_CTL2"
      sgroup "LDO2_MODE_CTL2 (at 0x14145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_EN_CTL"
      sgroup "LDO2_EN_CTL (at 0x14146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_PD_CTL"
      sgroup "LDO2_PD_CTL (at 0x14148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO2_CURRENT_LIM_CTL"
      sgroup "LDO2_CURRENT_LIM_CTL (at 0x1414a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO2_SOFT_START_CTL"
      sgroup "LDO2_SOFT_START_CTL (at 0x1414c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO2_CONFIG_CTL"
      sgroup "LDO2_CONFIG_CTL (at 0x14152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO2_VS_CTL"
      sgroup "LDO2_VS_CTL (at 0x14161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL1"
      sgroup "LDO2_LL_VOLTAGE_CTL1 (at 0x14168)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL2"
      sgroup "LDO2_LL_VOLTAGE_CTL2 (at 0x14169)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL1"
      sgroup "LDO2_UL_VOLTAGE_CTL1 (at 0x1416a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL2"
      sgroup "LDO2_UL_VOLTAGE_CTL2 (at 0x1416b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO2_SEC_ACCESS"
      sgroup "LDO2_SEC_ACCESS (at 0x141d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO2_PERPH_RESET_CTL1"
      sgroup "LDO2_PERPH_RESET_CTL1 (at 0x141d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL2"
      sgroup "LDO2_PERPH_RESET_CTL2 (at 0x141d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL3"
      sgroup "LDO2_PERPH_RESET_CTL3 (at 0x141da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL4"
      sgroup "LDO2_PERPH_RESET_CTL4 (at 0x141db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO2_INT_TEST1"
      sgroup "LDO2_INT_TEST1 (at 0x141e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO2_INT_TEST_VAL"
      sgroup "LDO2_INT_TEST_VAL (at 0x141e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO2_TEST1"
      sgroup "LDO2_TEST1 (at 0x141e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO2_TEST2"
      sgroup "LDO2_TEST2 (at 0x141e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO2_TRIM_NUM"
      sgroup "LDO2_TRIM_NUM (at 0x141f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO2_TRIM_CTRL"
      sgroup "LDO2_TRIM_CTRL (at 0x141f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO3"
  tree "LDO3"
    tree "LDO3_REVISION1"
      sgroup "LDO3_REVISION1 (at 0x14200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO3_REVISION2"
      sgroup "LDO3_REVISION2 (at 0x14201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO3_REVISION3"
      sgroup "LDO3_REVISION3 (at 0x14202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO3_REVISION4"
      sgroup "LDO3_REVISION4 (at 0x14203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO3_PERPH_TYPE"
      sgroup "LDO3_PERPH_TYPE (at 0x14204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO3_PERPH_SUBTYPE"
      sgroup "LDO3_PERPH_SUBTYPE (at 0x14205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO3_STATUS1"
      sgroup "LDO3_STATUS1 (at 0x14208)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO3_STATUS2"
      sgroup "LDO3_STATUS2 (at 0x14209)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO3_STATUS3"
      sgroup "LDO3_STATUS3 (at 0x1420a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80420a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x420a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO3_INT_RT_STS"
      sgroup "LDO3_INT_RT_STS (at 0x14210)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_SET_TYPE"
      sgroup "LDO3_INT_SET_TYPE (at 0x14211)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_HIGH"
      sgroup "LDO3_INT_POLARITY_HIGH (at 0x14212)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_LOW"
      sgroup "LDO3_INT_POLARITY_LOW (at 0x14213)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO3_INT_LATCHED_CLR"
      sgroup "LDO3_INT_LATCHED_CLR (at 0x14214)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO3_INT_EN_SET"
      sgroup "LDO3_INT_EN_SET (at 0x14215)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_EN_CLR"
      sgroup "LDO3_INT_EN_CLR (at 0x14216)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_LATCHED_STS"
      sgroup "LDO3_INT_LATCHED_STS (at 0x14218)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO3_INT_PENDING_STS"
      sgroup "LDO3_INT_PENDING_STS (at 0x14219)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_MID_SEL"
      sgroup "LDO3_INT_MID_SEL (at 0x1421a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO3_INT_PRIORITY"
      sgroup "LDO3_INT_PRIORITY (at 0x1421b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO3_VOLTAGE_CTL1"
      sgroup "LDO3_VOLTAGE_CTL1 (at 0x14240)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_VOLTAGE_CTL2"
      sgroup "LDO3_VOLTAGE_CTL2 (at 0x14241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO3_MODE_CTL2"
      sgroup "LDO3_MODE_CTL2 (at 0x14245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_EN_CTL"
      sgroup "LDO3_EN_CTL (at 0x14246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_PD_CTL"
      sgroup "LDO3_PD_CTL (at 0x14248)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO3_CURRENT_LIM_CTL"
      sgroup "LDO3_CURRENT_LIM_CTL (at 0x1424a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80424a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x424a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO3_SOFT_START_CTL"
      sgroup "LDO3_SOFT_START_CTL (at 0x1424c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80424c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x424c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO3_CONFIG_CTL"
      sgroup "LDO3_CONFIG_CTL (at 0x14252)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO3_VS_CTL"
      sgroup "LDO3_VS_CTL (at 0x14261)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL1"
      sgroup "LDO3_LL_VOLTAGE_CTL1 (at 0x14268)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL2"
      sgroup "LDO3_LL_VOLTAGE_CTL2 (at 0x14269)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL1"
      sgroup "LDO3_UL_VOLTAGE_CTL1 (at 0x1426a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80426a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x426a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL2"
      sgroup "LDO3_UL_VOLTAGE_CTL2 (at 0x1426b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80426b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x426b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO3_SEC_ACCESS"
      sgroup "LDO3_SEC_ACCESS (at 0x142d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO3_PERPH_RESET_CTL1"
      sgroup "LDO3_PERPH_RESET_CTL1 (at 0x142d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL2"
      sgroup "LDO3_PERPH_RESET_CTL2 (at 0x142d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL3"
      sgroup "LDO3_PERPH_RESET_CTL3 (at 0x142da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL4"
      sgroup "LDO3_PERPH_RESET_CTL4 (at 0x142db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO3_INT_TEST1"
      sgroup "LDO3_INT_TEST1 (at 0x142e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO3_INT_TEST_VAL"
      sgroup "LDO3_INT_TEST_VAL (at 0x142e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO3_TEST1"
      sgroup "LDO3_TEST1 (at 0x142e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO3_TEST2"
      sgroup "LDO3_TEST2 (at 0x142e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO3_TRIM_NUM"
      sgroup "LDO3_TRIM_NUM (at 0x142f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO3_TRIM_CTRL"
      sgroup "LDO3_TRIM_CTRL (at 0x142f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO4"
  tree "LDO4"
    tree "LDO4_REVISION1"
      sgroup "LDO4_REVISION1 (at 0x14300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO4_REVISION2"
      sgroup "LDO4_REVISION2 (at 0x14301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO4_REVISION3"
      sgroup "LDO4_REVISION3 (at 0x14302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO4_REVISION4"
      sgroup "LDO4_REVISION4 (at 0x14303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO4_PERPH_TYPE"
      sgroup "LDO4_PERPH_TYPE (at 0x14304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO4_PERPH_SUBTYPE"
      sgroup "LDO4_PERPH_SUBTYPE (at 0x14305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO4_STATUS1"
      sgroup "LDO4_STATUS1 (at 0x14308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO4_STATUS2"
      sgroup "LDO4_STATUS2 (at 0x14309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO4_STATUS3"
      sgroup "LDO4_STATUS3 (at 0x1430a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80430a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x430a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO4_INT_RT_STS"
      sgroup "LDO4_INT_RT_STS (at 0x14310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_SET_TYPE"
      sgroup "LDO4_INT_SET_TYPE (at 0x14311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_HIGH"
      sgroup "LDO4_INT_POLARITY_HIGH (at 0x14312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_LOW"
      sgroup "LDO4_INT_POLARITY_LOW (at 0x14313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO4_INT_LATCHED_CLR"
      sgroup "LDO4_INT_LATCHED_CLR (at 0x14314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO4_INT_EN_SET"
      sgroup "LDO4_INT_EN_SET (at 0x14315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_EN_CLR"
      sgroup "LDO4_INT_EN_CLR (at 0x14316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_LATCHED_STS"
      sgroup "LDO4_INT_LATCHED_STS (at 0x14318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO4_INT_PENDING_STS"
      sgroup "LDO4_INT_PENDING_STS (at 0x14319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_MID_SEL"
      sgroup "LDO4_INT_MID_SEL (at 0x1431a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO4_INT_PRIORITY"
      sgroup "LDO4_INT_PRIORITY (at 0x1431b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO4_VOLTAGE_CTL1"
      sgroup "LDO4_VOLTAGE_CTL1 (at 0x14340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_VOLTAGE_CTL2"
      sgroup "LDO4_VOLTAGE_CTL2 (at 0x14341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO4_MODE_CTL2"
      sgroup "LDO4_MODE_CTL2 (at 0x14345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_EN_CTL"
      sgroup "LDO4_EN_CTL (at 0x14346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_PD_CTL"
      sgroup "LDO4_PD_CTL (at 0x14348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO4_CURRENT_LIM_CTL"
      sgroup "LDO4_CURRENT_LIM_CTL (at 0x1434a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80434a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x434a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO4_SOFT_START_CTL"
      sgroup "LDO4_SOFT_START_CTL (at 0x1434c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80434c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x434c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO4_CONFIG_CTL"
      sgroup "LDO4_CONFIG_CTL (at 0x14352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL1"
      sgroup "LDO4_LL_VOLTAGE_CTL1 (at 0x14368)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL2"
      sgroup "LDO4_LL_VOLTAGE_CTL2 (at 0x14369)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL1"
      sgroup "LDO4_UL_VOLTAGE_CTL1 (at 0x1436a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80436a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x436a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL2"
      sgroup "LDO4_UL_VOLTAGE_CTL2 (at 0x1436b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80436b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x436b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO4_SEC_ACCESS"
      sgroup "LDO4_SEC_ACCESS (at 0x143d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO4_PERPH_RESET_CTL1"
      sgroup "LDO4_PERPH_RESET_CTL1 (at 0x143d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL2"
      sgroup "LDO4_PERPH_RESET_CTL2 (at 0x143d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL3"
      sgroup "LDO4_PERPH_RESET_CTL3 (at 0x143da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL4"
      sgroup "LDO4_PERPH_RESET_CTL4 (at 0x143db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO4_INT_TEST1"
      sgroup "LDO4_INT_TEST1 (at 0x143e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO4_INT_TEST_VAL"
      sgroup "LDO4_INT_TEST_VAL (at 0x143e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO4_TEST1"
      sgroup "LDO4_TEST1 (at 0x143e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO4_TEST2"
      sgroup "LDO4_TEST2 (at 0x143e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO4_TRIM_NUM"
      sgroup "LDO4_TRIM_NUM (at 0x143f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO4_TRIM_CTRL"
      sgroup "LDO4_TRIM_CTRL (at 0x143f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO5"
  tree "LDO5"
    tree "LDO5_REVISION1"
      sgroup "LDO5_REVISION1 (at 0x14400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO5_REVISION2"
      sgroup "LDO5_REVISION2 (at 0x14401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO5_REVISION3"
      sgroup "LDO5_REVISION3 (at 0x14402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO5_REVISION4"
      sgroup "LDO5_REVISION4 (at 0x14403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO5_PERPH_TYPE"
      sgroup "LDO5_PERPH_TYPE (at 0x14404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO5_PERPH_SUBTYPE"
      sgroup "LDO5_PERPH_SUBTYPE (at 0x14405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO5_STATUS1"
      sgroup "LDO5_STATUS1 (at 0x14408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO5_STATUS2"
      sgroup "LDO5_STATUS2 (at 0x14409)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO5_STATUS3"
      sgroup "LDO5_STATUS3 (at 0x1440a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80440a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x440a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO5_INT_RT_STS"
      sgroup "LDO5_INT_RT_STS (at 0x14410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_SET_TYPE"
      sgroup "LDO5_INT_SET_TYPE (at 0x14411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_HIGH"
      sgroup "LDO5_INT_POLARITY_HIGH (at 0x14412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_LOW"
      sgroup "LDO5_INT_POLARITY_LOW (at 0x14413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO5_INT_LATCHED_CLR"
      sgroup "LDO5_INT_LATCHED_CLR (at 0x14414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO5_INT_EN_SET"
      sgroup "LDO5_INT_EN_SET (at 0x14415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_EN_CLR"
      sgroup "LDO5_INT_EN_CLR (at 0x14416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_LATCHED_STS"
      sgroup "LDO5_INT_LATCHED_STS (at 0x14418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO5_INT_PENDING_STS"
      sgroup "LDO5_INT_PENDING_STS (at 0x14419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_MID_SEL"
      sgroup "LDO5_INT_MID_SEL (at 0x1441a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO5_INT_PRIORITY"
      sgroup "LDO5_INT_PRIORITY (at 0x1441b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO5_VOLTAGE_CTL1"
      sgroup "LDO5_VOLTAGE_CTL1 (at 0x14440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_VOLTAGE_CTL2"
      sgroup "LDO5_VOLTAGE_CTL2 (at 0x14441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO5_MODE_CTL2"
      sgroup "LDO5_MODE_CTL2 (at 0x14445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_EN_CTL"
      sgroup "LDO5_EN_CTL (at 0x14446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_PD_CTL"
      sgroup "LDO5_PD_CTL (at 0x14448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO5_CURRENT_LIM_CTL"
      sgroup "LDO5_CURRENT_LIM_CTL (at 0x1444a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80444a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x444a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO5_SOFT_START_CTL"
      sgroup "LDO5_SOFT_START_CTL (at 0x1444c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80444c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x444c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO5_CONFIG_CTL"
      sgroup "LDO5_CONFIG_CTL (at 0x14452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL1"
      sgroup "LDO5_LL_VOLTAGE_CTL1 (at 0x14468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL2"
      sgroup "LDO5_LL_VOLTAGE_CTL2 (at 0x14469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL1"
      sgroup "LDO5_UL_VOLTAGE_CTL1 (at 0x1446a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80446a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x446a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL2"
      sgroup "LDO5_UL_VOLTAGE_CTL2 (at 0x1446b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80446b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x446b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO5_SEC_ACCESS"
      sgroup "LDO5_SEC_ACCESS (at 0x144d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO5_PERPH_RESET_CTL1"
      sgroup "LDO5_PERPH_RESET_CTL1 (at 0x144d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL2"
      sgroup "LDO5_PERPH_RESET_CTL2 (at 0x144d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL3"
      sgroup "LDO5_PERPH_RESET_CTL3 (at 0x144da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL4"
      sgroup "LDO5_PERPH_RESET_CTL4 (at 0x144db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO5_INT_TEST1"
      sgroup "LDO5_INT_TEST1 (at 0x144e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO5_INT_TEST_VAL"
      sgroup "LDO5_INT_TEST_VAL (at 0x144e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO5_TEST1"
      sgroup "LDO5_TEST1 (at 0x144e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO5_TEST2"
      sgroup "LDO5_TEST2 (at 0x144e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO5_TRIM_NUM"
      sgroup "LDO5_TRIM_NUM (at 0x144f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO5_TRIM_CTRL"
      sgroup "LDO5_TRIM_CTRL (at 0x144f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO6"
  tree "LDO6"
    tree "LDO6_REVISION1"
      sgroup "LDO6_REVISION1 (at 0x14500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO6_REVISION2"
      sgroup "LDO6_REVISION2 (at 0x14501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO6_REVISION3"
      sgroup "LDO6_REVISION3 (at 0x14502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO6_REVISION4"
      sgroup "LDO6_REVISION4 (at 0x14503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO6_PERPH_TYPE"
      sgroup "LDO6_PERPH_TYPE (at 0x14504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO6_PERPH_SUBTYPE"
      sgroup "LDO6_PERPH_SUBTYPE (at 0x14505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO6_STATUS1"
      sgroup "LDO6_STATUS1 (at 0x14508)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO6_STATUS2"
      sgroup "LDO6_STATUS2 (at 0x14509)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO6_STATUS3"
      sgroup "LDO6_STATUS3 (at 0x1450a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO6_INT_RT_STS"
      sgroup "LDO6_INT_RT_STS (at 0x14510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_SET_TYPE"
      sgroup "LDO6_INT_SET_TYPE (at 0x14511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_HIGH"
      sgroup "LDO6_INT_POLARITY_HIGH (at 0x14512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_LOW"
      sgroup "LDO6_INT_POLARITY_LOW (at 0x14513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO6_INT_LATCHED_CLR"
      sgroup "LDO6_INT_LATCHED_CLR (at 0x14514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO6_INT_EN_SET"
      sgroup "LDO6_INT_EN_SET (at 0x14515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_EN_CLR"
      sgroup "LDO6_INT_EN_CLR (at 0x14516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_LATCHED_STS"
      sgroup "LDO6_INT_LATCHED_STS (at 0x14518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO6_INT_PENDING_STS"
      sgroup "LDO6_INT_PENDING_STS (at 0x14519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_MID_SEL"
      sgroup "LDO6_INT_MID_SEL (at 0x1451a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO6_INT_PRIORITY"
      sgroup "LDO6_INT_PRIORITY (at 0x1451b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO6_VOLTAGE_CTL1"
      sgroup "LDO6_VOLTAGE_CTL1 (at 0x14540)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_VOLTAGE_CTL2"
      sgroup "LDO6_VOLTAGE_CTL2 (at 0x14541)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO6_MODE_CTL2"
      sgroup "LDO6_MODE_CTL2 (at 0x14545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_EN_CTL"
      sgroup "LDO6_EN_CTL (at 0x14546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_PD_CTL"
      sgroup "LDO6_PD_CTL (at 0x14548)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO6_CURRENT_LIM_CTL"
      sgroup "LDO6_CURRENT_LIM_CTL (at 0x1454a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80454a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x454a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO6_SOFT_START_CTL"
      sgroup "LDO6_SOFT_START_CTL (at 0x1454c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80454c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x454c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO6_CONFIG_CTL"
      sgroup "LDO6_CONFIG_CTL (at 0x14552)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL1"
      sgroup "LDO6_LL_VOLTAGE_CTL1 (at 0x14568)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL2"
      sgroup "LDO6_LL_VOLTAGE_CTL2 (at 0x14569)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL1"
      sgroup "LDO6_UL_VOLTAGE_CTL1 (at 0x1456a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80456a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x456a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL2"
      sgroup "LDO6_UL_VOLTAGE_CTL2 (at 0x1456b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80456b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x456b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO6_SEC_ACCESS"
      sgroup "LDO6_SEC_ACCESS (at 0x145d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO6_PERPH_RESET_CTL1"
      sgroup "LDO6_PERPH_RESET_CTL1 (at 0x145d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL2"
      sgroup "LDO6_PERPH_RESET_CTL2 (at 0x145d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL3"
      sgroup "LDO6_PERPH_RESET_CTL3 (at 0x145da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL4"
      sgroup "LDO6_PERPH_RESET_CTL4 (at 0x145db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO6_INT_TEST1"
      sgroup "LDO6_INT_TEST1 (at 0x145e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO6_INT_TEST_VAL"
      sgroup "LDO6_INT_TEST_VAL (at 0x145e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO6_TEST1"
      sgroup "LDO6_TEST1 (at 0x145e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO6_TEST2"
      sgroup "LDO6_TEST2 (at 0x145e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO6_TRIM_NUM"
      sgroup "LDO6_TRIM_NUM (at 0x145f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO6_TRIM_CTRL"
      sgroup "LDO6_TRIM_CTRL (at 0x145f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO7"
  tree "LDO7"
    tree "LDO7_REVISION1"
      sgroup "LDO7_REVISION1 (at 0x14600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO7_REVISION2"
      sgroup "LDO7_REVISION2 (at 0x14601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO7_REVISION3"
      sgroup "LDO7_REVISION3 (at 0x14602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO7_REVISION4"
      sgroup "LDO7_REVISION4 (at 0x14603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO7_PERPH_TYPE"
      sgroup "LDO7_PERPH_TYPE (at 0x14604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO7_PERPH_SUBTYPE"
      sgroup "LDO7_PERPH_SUBTYPE (at 0x14605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO7_STATUS1"
      sgroup "LDO7_STATUS1 (at 0x14608)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO7_STATUS2"
      sgroup "LDO7_STATUS2 (at 0x14609)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO7_STATUS3"
      sgroup "LDO7_STATUS3 (at 0x1460a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80460a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x460a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO7_INT_RT_STS"
      sgroup "LDO7_INT_RT_STS (at 0x14610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_SET_TYPE"
      sgroup "LDO7_INT_SET_TYPE (at 0x14611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_HIGH"
      sgroup "LDO7_INT_POLARITY_HIGH (at 0x14612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_LOW"
      sgroup "LDO7_INT_POLARITY_LOW (at 0x14613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO7_INT_LATCHED_CLR"
      sgroup "LDO7_INT_LATCHED_CLR (at 0x14614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO7_INT_EN_SET"
      sgroup "LDO7_INT_EN_SET (at 0x14615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_EN_CLR"
      sgroup "LDO7_INT_EN_CLR (at 0x14616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_LATCHED_STS"
      sgroup "LDO7_INT_LATCHED_STS (at 0x14618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO7_INT_PENDING_STS"
      sgroup "LDO7_INT_PENDING_STS (at 0x14619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_MID_SEL"
      sgroup "LDO7_INT_MID_SEL (at 0x1461a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO7_INT_PRIORITY"
      sgroup "LDO7_INT_PRIORITY (at 0x1461b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO7_VOLTAGE_CTL1"
      sgroup "LDO7_VOLTAGE_CTL1 (at 0x14640)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_VOLTAGE_CTL2"
      sgroup "LDO7_VOLTAGE_CTL2 (at 0x14641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO7_MODE_CTL2"
      sgroup "LDO7_MODE_CTL2 (at 0x14645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_EN_CTL"
      sgroup "LDO7_EN_CTL (at 0x14646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_PD_CTL"
      sgroup "LDO7_PD_CTL (at 0x14648)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO7_CURRENT_LIM_CTL"
      sgroup "LDO7_CURRENT_LIM_CTL (at 0x1464a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO7_SOFT_START_CTL"
      sgroup "LDO7_SOFT_START_CTL (at 0x1464c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO7_CONFIG_CTL"
      sgroup "LDO7_CONFIG_CTL (at 0x14652)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL1"
      sgroup "LDO7_LL_VOLTAGE_CTL1 (at 0x14668)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL2"
      sgroup "LDO7_LL_VOLTAGE_CTL2 (at 0x14669)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL1"
      sgroup "LDO7_UL_VOLTAGE_CTL1 (at 0x1466a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL2"
      sgroup "LDO7_UL_VOLTAGE_CTL2 (at 0x1466b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO7_SEC_ACCESS"
      sgroup "LDO7_SEC_ACCESS (at 0x146d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO7_PERPH_RESET_CTL1"
      sgroup "LDO7_PERPH_RESET_CTL1 (at 0x146d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL2"
      sgroup "LDO7_PERPH_RESET_CTL2 (at 0x146d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL3"
      sgroup "LDO7_PERPH_RESET_CTL3 (at 0x146da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL4"
      sgroup "LDO7_PERPH_RESET_CTL4 (at 0x146db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO7_INT_TEST1"
      sgroup "LDO7_INT_TEST1 (at 0x146e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO7_INT_TEST_VAL"
      sgroup "LDO7_INT_TEST_VAL (at 0x146e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO7_TEST1"
      sgroup "LDO7_TEST1 (at 0x146e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO7_TEST2"
      sgroup "LDO7_TEST2 (at 0x146e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO7_TRIM_NUM"
      sgroup "LDO7_TRIM_NUM (at 0x146f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO7_TRIM_CTRL"
      sgroup "LDO7_TRIM_CTRL (at 0x146f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO8"
  tree "LDO8"
    tree "LDO8_REVISION1"
      sgroup "LDO8_REVISION1 (at 0x14700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO8_REVISION2"
      sgroup "LDO8_REVISION2 (at 0x14701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO8_REVISION3"
      sgroup "LDO8_REVISION3 (at 0x14702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO8_REVISION4"
      sgroup "LDO8_REVISION4 (at 0x14703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO8_PERPH_TYPE"
      sgroup "LDO8_PERPH_TYPE (at 0x14704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO8_PERPH_SUBTYPE"
      sgroup "LDO8_PERPH_SUBTYPE (at 0x14705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO8_STATUS1"
      sgroup "LDO8_STATUS1 (at 0x14708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO8_STATUS2"
      sgroup "LDO8_STATUS2 (at 0x14709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO8_STATUS3"
      sgroup "LDO8_STATUS3 (at 0x1470a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80470a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x470a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO8_INT_RT_STS"
      sgroup "LDO8_INT_RT_STS (at 0x14710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_SET_TYPE"
      sgroup "LDO8_INT_SET_TYPE (at 0x14711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_HIGH"
      sgroup "LDO8_INT_POLARITY_HIGH (at 0x14712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_LOW"
      sgroup "LDO8_INT_POLARITY_LOW (at 0x14713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO8_INT_LATCHED_CLR"
      sgroup "LDO8_INT_LATCHED_CLR (at 0x14714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO8_INT_EN_SET"
      sgroup "LDO8_INT_EN_SET (at 0x14715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_EN_CLR"
      sgroup "LDO8_INT_EN_CLR (at 0x14716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_LATCHED_STS"
      sgroup "LDO8_INT_LATCHED_STS (at 0x14718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO8_INT_PENDING_STS"
      sgroup "LDO8_INT_PENDING_STS (at 0x14719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_MID_SEL"
      sgroup "LDO8_INT_MID_SEL (at 0x1471a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO8_INT_PRIORITY"
      sgroup "LDO8_INT_PRIORITY (at 0x1471b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO8_VOLTAGE_CTL1"
      sgroup "LDO8_VOLTAGE_CTL1 (at 0x14740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_VOLTAGE_CTL2"
      sgroup "LDO8_VOLTAGE_CTL2 (at 0x14741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO8_MODE_CTL2"
      sgroup "LDO8_MODE_CTL2 (at 0x14745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_EN_CTL"
      sgroup "LDO8_EN_CTL (at 0x14746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_PD_CTL"
      sgroup "LDO8_PD_CTL (at 0x14748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO8_CURRENT_LIM_CTL"
      sgroup "LDO8_CURRENT_LIM_CTL (at 0x1474a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80474a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x474a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO8_SOFT_START_CTL"
      sgroup "LDO8_SOFT_START_CTL (at 0x1474c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80474c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x474c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO8_CONFIG_CTL"
      sgroup "LDO8_CONFIG_CTL (at 0x14752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL1"
      sgroup "LDO8_LL_VOLTAGE_CTL1 (at 0x14768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL2"
      sgroup "LDO8_LL_VOLTAGE_CTL2 (at 0x14769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL1"
      sgroup "LDO8_UL_VOLTAGE_CTL1 (at 0x1476a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80476a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x476a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL2"
      sgroup "LDO8_UL_VOLTAGE_CTL2 (at 0x1476b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80476b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x476b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO8_SEC_ACCESS"
      sgroup "LDO8_SEC_ACCESS (at 0x147d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO8_PERPH_RESET_CTL1"
      sgroup "LDO8_PERPH_RESET_CTL1 (at 0x147d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL2"
      sgroup "LDO8_PERPH_RESET_CTL2 (at 0x147d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL3"
      sgroup "LDO8_PERPH_RESET_CTL3 (at 0x147da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL4"
      sgroup "LDO8_PERPH_RESET_CTL4 (at 0x147db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO8_INT_TEST1"
      sgroup "LDO8_INT_TEST1 (at 0x147e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO8_INT_TEST_VAL"
      sgroup "LDO8_INT_TEST_VAL (at 0x147e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO8_TEST1"
      sgroup "LDO8_TEST1 (at 0x147e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO8_TEST2"
      sgroup "LDO8_TEST2 (at 0x147e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO8_TRIM_NUM"
      sgroup "LDO8_TRIM_NUM (at 0x147f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO8_TRIM_CTRL"
      sgroup "LDO8_TRIM_CTRL (at 0x147f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO9"
  tree "LDO9"
    tree "LDO9_REVISION1"
      sgroup "LDO9_REVISION1 (at 0x14800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO9_REVISION2"
      sgroup "LDO9_REVISION2 (at 0x14801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO9_REVISION3"
      sgroup "LDO9_REVISION3 (at 0x14802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO9_REVISION4"
      sgroup "LDO9_REVISION4 (at 0x14803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO9_PERPH_TYPE"
      sgroup "LDO9_PERPH_TYPE (at 0x14804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO9_PERPH_SUBTYPE"
      sgroup "LDO9_PERPH_SUBTYPE (at 0x14805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO9_STATUS1"
      sgroup "LDO9_STATUS1 (at 0x14808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO9_STATUS2"
      sgroup "LDO9_STATUS2 (at 0x14809)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO9_STATUS3"
      sgroup "LDO9_STATUS3 (at 0x1480a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80480a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x480a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO9_INT_RT_STS"
      sgroup "LDO9_INT_RT_STS (at 0x14810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_SET_TYPE"
      sgroup "LDO9_INT_SET_TYPE (at 0x14811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_HIGH"
      sgroup "LDO9_INT_POLARITY_HIGH (at 0x14812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_LOW"
      sgroup "LDO9_INT_POLARITY_LOW (at 0x14813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO9_INT_LATCHED_CLR"
      sgroup "LDO9_INT_LATCHED_CLR (at 0x14814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO9_INT_EN_SET"
      sgroup "LDO9_INT_EN_SET (at 0x14815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_EN_CLR"
      sgroup "LDO9_INT_EN_CLR (at 0x14816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_LATCHED_STS"
      sgroup "LDO9_INT_LATCHED_STS (at 0x14818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO9_INT_PENDING_STS"
      sgroup "LDO9_INT_PENDING_STS (at 0x14819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_MID_SEL"
      sgroup "LDO9_INT_MID_SEL (at 0x1481a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO9_INT_PRIORITY"
      sgroup "LDO9_INT_PRIORITY (at 0x1481b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO9_VOLTAGE_CTL1"
      sgroup "LDO9_VOLTAGE_CTL1 (at 0x14840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_VOLTAGE_CTL2"
      sgroup "LDO9_VOLTAGE_CTL2 (at 0x14841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO9_MODE_CTL2"
      sgroup "LDO9_MODE_CTL2 (at 0x14845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_EN_CTL"
      sgroup "LDO9_EN_CTL (at 0x14846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_PD_CTL"
      sgroup "LDO9_PD_CTL (at 0x14848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO9_CURRENT_LIM_CTL"
      sgroup "LDO9_CURRENT_LIM_CTL (at 0x1484a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80484a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x484a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO9_SOFT_START_CTL"
      sgroup "LDO9_SOFT_START_CTL (at 0x1484c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80484c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x484c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO9_CONFIG_CTL"
      sgroup "LDO9_CONFIG_CTL (at 0x14852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO9_VS_CTL"
      sgroup "LDO9_VS_CTL (at 0x14861)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL1"
      sgroup "LDO9_LL_VOLTAGE_CTL1 (at 0x14868)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL2"
      sgroup "LDO9_LL_VOLTAGE_CTL2 (at 0x14869)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL1"
      sgroup "LDO9_UL_VOLTAGE_CTL1 (at 0x1486a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80486a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x486a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL2"
      sgroup "LDO9_UL_VOLTAGE_CTL2 (at 0x1486b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80486b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x486b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO9_SEC_ACCESS"
      sgroup "LDO9_SEC_ACCESS (at 0x148d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO9_PERPH_RESET_CTL1"
      sgroup "LDO9_PERPH_RESET_CTL1 (at 0x148d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL2"
      sgroup "LDO9_PERPH_RESET_CTL2 (at 0x148d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL3"
      sgroup "LDO9_PERPH_RESET_CTL3 (at 0x148da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL4"
      sgroup "LDO9_PERPH_RESET_CTL4 (at 0x148db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO9_INT_TEST1"
      sgroup "LDO9_INT_TEST1 (at 0x148e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO9_INT_TEST_VAL"
      sgroup "LDO9_INT_TEST_VAL (at 0x148e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO9_TEST1"
      sgroup "LDO9_TEST1 (at 0x148e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO9_TEST2"
      sgroup "LDO9_TEST2 (at 0x148e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO9_TRIM_NUM"
      sgroup "LDO9_TRIM_NUM (at 0x148f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO9_TRIM_CTRL"
      sgroup "LDO9_TRIM_CTRL (at 0x148f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO_RFCLK"
  tree "LDO_RFCLK"
    tree "LDO_RFCLK_REVISION1"
      sgroup "LDO_RFCLK_REVISION1 (at 0x15100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION2"
      sgroup "LDO_RFCLK_REVISION2 (at 0x15101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION3"
      sgroup "LDO_RFCLK_REVISION3 (at 0x15102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION4"
      sgroup "LDO_RFCLK_REVISION4 (at 0x15103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_PERPH_TYPE"
      sgroup "LDO_RFCLK_PERPH_TYPE (at 0x15104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_RFCLK_PERPH_SUBTYPE"
      sgroup "LDO_RFCLK_PERPH_SUBTYPE (at 0x15105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_RFCLK_STATUS1"
      sgroup "LDO_RFCLK_STATUS1 (at 0x15108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL1"
      sgroup "LDO_RFCLK_VOLTAGE_CTL1 (at 0x15140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL2"
      sgroup "LDO_RFCLK_VOLTAGE_CTL2 (at 0x15141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_RFCLK_MODE_CTL2"
      sgroup "LDO_RFCLK_MODE_CTL2 (at 0x15145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_RFCLK_EN_CTL"
      sgroup "LDO_RFCLK_EN_CTL (at 0x15146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_RFCLK_SEC_ACCESS"
      sgroup "LDO_RFCLK_SEC_ACCESS (at 0x151d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL1"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL1 (at 0x151d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL2"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL2 (at 0x151d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL3"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL3 (at 0x151da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL4"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL4 (at 0x151db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_TEST1"
      sgroup "LDO_RFCLK_TEST1 (at 0x151e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO_XO"
  tree "LDO_XO"
    tree "LDO_XO_REVISION1"
      sgroup "LDO_XO_REVISION1 (at 0x15000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION2"
      sgroup "LDO_XO_REVISION2 (at 0x15001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_XO_REVISION3"
      sgroup "LDO_XO_REVISION3 (at 0x15002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION4"
      sgroup "LDO_XO_REVISION4 (at 0x15003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_XO_PERPH_TYPE"
      sgroup "LDO_XO_PERPH_TYPE (at 0x15004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_XO_PERPH_SUBTYPE"
      sgroup "LDO_XO_PERPH_SUBTYPE (at 0x15005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_XO_STATUS1"
      sgroup "LDO_XO_STATUS1 (at 0x15008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL1"
      sgroup "LDO_XO_VOLTAGE_CTL1 (at 0x15040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL2"
      sgroup "LDO_XO_VOLTAGE_CTL2 (at 0x15041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_XO_MODE_CTL2"
      sgroup "LDO_XO_MODE_CTL2 (at 0x15045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_XO_EN_CTL"
      sgroup "LDO_XO_EN_CTL (at 0x15046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_XO_SEC_ACCESS"
      sgroup "LDO_XO_SEC_ACCESS (at 0x150d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL1"
      sgroup "LDO_XO_PERPH_RESET_CTL1 (at 0x150d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL2"
      sgroup "LDO_XO_PERPH_RESET_CTL2 (at 0x150d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL3"
      sgroup "LDO_XO_PERPH_RESET_CTL3 (at 0x150da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL4"
      sgroup "LDO_XO_PERPH_RESET_CTL4 (at 0x150db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_XO_TEST1"
      sgroup "LDO_XO_TEST1 (at 0x150e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LN_BB_CLK"
  tree "LN_BB_CLK"
    tree "LN_BB_CLK_REVISION1"
      sgroup "LN_BB_CLK_REVISION1 (at 0x5200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION2"
      sgroup "LN_BB_CLK_REVISION2 (at 0x5201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION3"
      sgroup "LN_BB_CLK_REVISION3 (at 0x5202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION4"
      sgroup "LN_BB_CLK_REVISION4 (at 0x5203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_PERPH_TYPE"
      sgroup "LN_BB_CLK_PERPH_TYPE (at 0x5204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LN_BB_CLK_PERPH_SUBTYPE"
      sgroup "LN_BB_CLK_PERPH_SUBTYPE (at 0x5205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LN_BB_CLK_STATUS1"
      sgroup "LN_BB_CLK_STATUS1 (at 0x5208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "LN_BB_CLK_EDGE_CTL1"
      sgroup "LN_BB_CLK_EDGE_CTL1 (at 0x5243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "LN_BB_CLK_DRV_CTL1"
      sgroup "LN_BB_CLK_DRV_CTL1 (at 0x5244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_EN_CTL"
      sgroup "LN_BB_CLK_EN_CTL (at 0x5246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_PD_CTL"
      sgroup "LN_BB_CLK_PD_CTL (at 0x5248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "LN_BB_CLK_SEC_ACCESS"
      sgroup "LN_BB_CLK_SEC_ACCESS (at 0x52d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL1"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL1 (at 0x52d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL2"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL2 (at 0x52d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL3"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL3 (at 0x52da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL4"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL4 (at 0x52db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      sgroup "MISC_STATUS1 (at 0x908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GP1RESET                                 = " "0, 1"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1"
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0, 1"
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x7 1 "  [ 7: 1]   MISC_CTL                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VDD_LDO_XO_SEL                           = " "0, 1"
    tree.end
    tree "MISC_GP1RESET_CTL1"
      sgroup "MISC_GP1RESET_CTL1 (at 0x947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO3_GP1RESET_POLARITY                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GPIO3_GP1RESET_EN                        = " "0, 1"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP5"
  tree "MPP5"
    tree "MPP5_REVISION1"
      sgroup "MPP5_REVISION1 (at 0xa400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP5_REVISION2"
      sgroup "MPP5_REVISION2 (at 0xa401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP5_REVISION3"
      sgroup "MPP5_REVISION3 (at 0xa402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP5_REVISION4"
      sgroup "MPP5_REVISION4 (at 0xa403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP5_PERPH_TYPE"
      sgroup "MPP5_PERPH_TYPE (at 0xa404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP5_PERPH_SUBTYPE"
      sgroup "MPP5_PERPH_SUBTYPE (at 0xa405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP5_STATUS1"
      sgroup "MPP5_STATUS1 (at 0xa408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP5_INT_RT_STS"
      sgroup "MPP5_INT_RT_STS (at 0xa410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP5_INT_SET_TYPE"
      sgroup "MPP5_INT_SET_TYPE (at 0xa411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP5_INT_POLARITY_HIGH"
      sgroup "MPP5_INT_POLARITY_HIGH (at 0xa412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_POLARITY_LOW"
      sgroup "MPP5_INT_POLARITY_LOW (at 0xa413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_CLR"
      sgroup "MPP5_INT_LATCHED_CLR (at 0xa414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP5_INT_EN_SET"
      sgroup "MPP5_INT_EN_SET (at 0xa415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_EN_CLR"
      sgroup "MPP5_INT_EN_CLR (at 0xa416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_STS"
      sgroup "MPP5_INT_LATCHED_STS (at 0xa418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP5_INT_PENDING_STS"
      sgroup "MPP5_INT_PENDING_STS (at 0xa419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP5_INT_MID_SEL"
      sgroup "MPP5_INT_MID_SEL (at 0xa41a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP5_INT_PRIORITY"
      sgroup "MPP5_INT_PRIORITY (at 0xa41b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP5_MODE_CTL"
      sgroup "MPP5_MODE_CTL (at 0xa440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP5_DIG_VIN_CTL"
      sgroup "MPP5_DIG_VIN_CTL (at 0xa441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_PULL_CTL"
      sgroup "MPP5_DIG_PULL_CTL (at 0xa442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_IN_CTL"
      sgroup "MPP5_DIG_IN_CTL (at 0xa443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP5_EN_CTL"
      sgroup "MPP5_EN_CTL (at 0xa446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP5_ANA_OUT_CTL"
      sgroup "MPP5_ANA_OUT_CTL (at 0xa448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_ANA_IN_CTL"
      sgroup "MPP5_ANA_IN_CTL (at 0xa44a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a44a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa44a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_SINK_CTL"
      sgroup "MPP5_SINK_CTL (at 0xa44c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a44c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa44c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP5_SEC_ACCESS"
      sgroup "MPP5_SEC_ACCESS (at 0xa4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP5_PERPH_RESET_CTL1"
      sgroup "MPP5_PERPH_RESET_CTL1 (at 0xa4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL2"
      sgroup "MPP5_PERPH_RESET_CTL2 (at 0xa4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL3"
      sgroup "MPP5_PERPH_RESET_CTL3 (at 0xa4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL4"
      sgroup "MPP5_PERPH_RESET_CTL4 (at 0xa4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        set &access:&cmd_addr %l 0x80a4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP6"
  tree "MPP6"
    tree "MPP6_REVISION1"
      sgroup "MPP6_REVISION1 (at 0xa500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP6_REVISION2"
      sgroup "MPP6_REVISION2 (at 0xa501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP6_REVISION3"
      sgroup "MPP6_REVISION3 (at 0xa502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP6_REVISION4"
      sgroup "MPP6_REVISION4 (at 0xa503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP6_PERPH_TYPE"
      sgroup "MPP6_PERPH_TYPE (at 0xa504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP6_PERPH_SUBTYPE"
      sgroup "MPP6_PERPH_SUBTYPE (at 0xa505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP6_STATUS1"
      sgroup "MPP6_STATUS1 (at 0xa508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP6_INT_RT_STS"
      sgroup "MPP6_INT_RT_STS (at 0xa510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP6_INT_SET_TYPE"
      sgroup "MPP6_INT_SET_TYPE (at 0xa511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP6_INT_POLARITY_HIGH"
      sgroup "MPP6_INT_POLARITY_HIGH (at 0xa512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_POLARITY_LOW"
      sgroup "MPP6_INT_POLARITY_LOW (at 0xa513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_CLR"
      sgroup "MPP6_INT_LATCHED_CLR (at 0xa514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP6_INT_EN_SET"
      sgroup "MPP6_INT_EN_SET (at 0xa515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_EN_CLR"
      sgroup "MPP6_INT_EN_CLR (at 0xa516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_STS"
      sgroup "MPP6_INT_LATCHED_STS (at 0xa518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP6_INT_PENDING_STS"
      sgroup "MPP6_INT_PENDING_STS (at 0xa519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP6_INT_MID_SEL"
      sgroup "MPP6_INT_MID_SEL (at 0xa51a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP6_INT_PRIORITY"
      sgroup "MPP6_INT_PRIORITY (at 0xa51b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP6_MODE_CTL"
      sgroup "MPP6_MODE_CTL (at 0xa540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP6_DIG_VIN_CTL"
      sgroup "MPP6_DIG_VIN_CTL (at 0xa541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_PULL_CTL"
      sgroup "MPP6_DIG_PULL_CTL (at 0xa542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_IN_CTL"
      sgroup "MPP6_DIG_IN_CTL (at 0xa543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP6_EN_CTL"
      sgroup "MPP6_EN_CTL (at 0xa546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP6_ANA_OUT_CTL"
      sgroup "MPP6_ANA_OUT_CTL (at 0xa548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_ANA_IN_CTL"
      sgroup "MPP6_ANA_IN_CTL (at 0xa54a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a54a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa54a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_SINK_CTL"
      sgroup "MPP6_SINK_CTL (at 0xa54c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a54c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa54c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP6_SEC_ACCESS"
      sgroup "MPP6_SEC_ACCESS (at 0xa5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP6_PERPH_RESET_CTL1"
      sgroup "MPP6_PERPH_RESET_CTL1 (at 0xa5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL2"
      sgroup "MPP6_PERPH_RESET_CTL2 (at 0xa5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL3"
      sgroup "MPP6_PERPH_RESET_CTL3 (at 0xa5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL4"
      sgroup "MPP6_PERPH_RESET_CTL4 (at 0xa5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        set &access:&cmd_addr %l 0x80a5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT10"
  tree "PBS_CLIENT10"
    tree "PBS_CLIENT10_REVISION1"
      sgroup "PBS_CLIENT10_REVISION1 (at 0x7b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION2"
      sgroup "PBS_CLIENT10_REVISION2 (at 0x7b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION3"
      sgroup "PBS_CLIENT10_REVISION3 (at 0x7b02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION4"
      sgroup "PBS_CLIENT10_REVISION4 (at 0x7b03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_PERPH_TYPE"
      sgroup "PBS_CLIENT10_PERPH_TYPE (at 0x7b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT10_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT10_PERPH_SUBTYPE (at 0x7b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT10_STATUS0"
      sgroup "PBS_CLIENT10_STATUS0 (at 0x7b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_STATUS1"
      sgroup "PBS_CLIENT10_STATUS1 (at 0x7b09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT10_INT_RT_STS"
      sgroup "PBS_CLIENT10_INT_RT_STS (at 0x7b10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT10_INT_SET_TYPE"
      sgroup "PBS_CLIENT10_INT_SET_TYPE (at 0x7b11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT10_INT_POLARITY_HIGH (at 0x7b12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT10_INT_POLARITY_LOW (at 0x7b13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT10_INT_LATCHED_CLR (at 0x7b14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_INT_EN_SET"
      sgroup "PBS_CLIENT10_INT_EN_SET (at 0x7b15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_EN_CLR"
      sgroup "PBS_CLIENT10_INT_EN_CLR (at 0x7b16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_STS"
      sgroup "PBS_CLIENT10_INT_LATCHED_STS (at 0x7b18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT10_INT_PENDING_STS"
      sgroup "PBS_CLIENT10_INT_PENDING_STS (at 0x7b19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT10_INT_MID_SEL"
      sgroup "PBS_CLIENT10_INT_MID_SEL (at 0x7b1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT10_INT_PRIORITY"
      sgroup "PBS_CLIENT10_INT_PRIORITY (at 0x7b1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_TRIG_CFG"
      sgroup "PBS_CLIENT10_TRIG_CFG (at 0x7b40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT10_TRIG_CTL"
      sgroup "PBS_CLIENT10_TRIG_CTL (at 0x7b42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_EN_CTL"
      sgroup "PBS_CLIENT10_EN_CTL (at 0x7b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_SEC_ACCESS"
      sgroup "PBS_CLIENT10_SEC_ACCESS (at 0x7bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL1 (at 0x7bd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL2 (at 0x7bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL3 (at 0x7bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL4 (at 0x7bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST1"
      sgroup "PBS_CLIENT10_INT_TEST1 (at 0x7be0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST_VAL"
      sgroup "PBS_CLIENT10_INT_TEST_VAL (at 0x7be1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        set &access:&cmd_addr %l 0x807be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT11"
  tree "PBS_CLIENT11"
    tree "PBS_CLIENT11_REVISION1"
      sgroup "PBS_CLIENT11_REVISION1 (at 0x7c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION2"
      sgroup "PBS_CLIENT11_REVISION2 (at 0x7c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION3"
      sgroup "PBS_CLIENT11_REVISION3 (at 0x7c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION4"
      sgroup "PBS_CLIENT11_REVISION4 (at 0x7c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_PERPH_TYPE"
      sgroup "PBS_CLIENT11_PERPH_TYPE (at 0x7c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT11_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT11_PERPH_SUBTYPE (at 0x7c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT11_STATUS0"
      sgroup "PBS_CLIENT11_STATUS0 (at 0x7c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_STATUS1"
      sgroup "PBS_CLIENT11_STATUS1 (at 0x7c09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT11_INT_RT_STS"
      sgroup "PBS_CLIENT11_INT_RT_STS (at 0x7c10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT11_INT_SET_TYPE"
      sgroup "PBS_CLIENT11_INT_SET_TYPE (at 0x7c11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT11_INT_POLARITY_HIGH (at 0x7c12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT11_INT_POLARITY_LOW (at 0x7c13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT11_INT_LATCHED_CLR (at 0x7c14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_INT_EN_SET"
      sgroup "PBS_CLIENT11_INT_EN_SET (at 0x7c15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_EN_CLR"
      sgroup "PBS_CLIENT11_INT_EN_CLR (at 0x7c16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_STS"
      sgroup "PBS_CLIENT11_INT_LATCHED_STS (at 0x7c18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT11_INT_PENDING_STS"
      sgroup "PBS_CLIENT11_INT_PENDING_STS (at 0x7c19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT11_INT_MID_SEL"
      sgroup "PBS_CLIENT11_INT_MID_SEL (at 0x7c1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT11_INT_PRIORITY"
      sgroup "PBS_CLIENT11_INT_PRIORITY (at 0x7c1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_TRIG_CFG"
      sgroup "PBS_CLIENT11_TRIG_CFG (at 0x7c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT11_TRIG_CTL"
      sgroup "PBS_CLIENT11_TRIG_CTL (at 0x7c42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_EN_CTL"
      sgroup "PBS_CLIENT11_EN_CTL (at 0x7c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_SEC_ACCESS"
      sgroup "PBS_CLIENT11_SEC_ACCESS (at 0x7cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL1 (at 0x7cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL2 (at 0x7cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL3 (at 0x7cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL4 (at 0x7cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST1"
      sgroup "PBS_CLIENT11_INT_TEST1 (at 0x7ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST_VAL"
      sgroup "PBS_CLIENT11_INT_TEST_VAL (at 0x7ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        set &access:&cmd_addr %l 0x807ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT12"
  tree "PBS_CLIENT12"
    tree "PBS_CLIENT12_REVISION1"
      sgroup "PBS_CLIENT12_REVISION1 (at 0x7d00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION2"
      sgroup "PBS_CLIENT12_REVISION2 (at 0x7d01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION3"
      sgroup "PBS_CLIENT12_REVISION3 (at 0x7d02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION4"
      sgroup "PBS_CLIENT12_REVISION4 (at 0x7d03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_PERPH_TYPE"
      sgroup "PBS_CLIENT12_PERPH_TYPE (at 0x7d04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT12_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT12_PERPH_SUBTYPE (at 0x7d05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT12_STATUS0"
      sgroup "PBS_CLIENT12_STATUS0 (at 0x7d08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_STATUS1"
      sgroup "PBS_CLIENT12_STATUS1 (at 0x7d09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT12_INT_RT_STS"
      sgroup "PBS_CLIENT12_INT_RT_STS (at 0x7d10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT12_INT_SET_TYPE"
      sgroup "PBS_CLIENT12_INT_SET_TYPE (at 0x7d11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT12_INT_POLARITY_HIGH (at 0x7d12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT12_INT_POLARITY_LOW (at 0x7d13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT12_INT_LATCHED_CLR (at 0x7d14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_INT_EN_SET"
      sgroup "PBS_CLIENT12_INT_EN_SET (at 0x7d15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_EN_CLR"
      sgroup "PBS_CLIENT12_INT_EN_CLR (at 0x7d16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_STS"
      sgroup "PBS_CLIENT12_INT_LATCHED_STS (at 0x7d18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT12_INT_PENDING_STS"
      sgroup "PBS_CLIENT12_INT_PENDING_STS (at 0x7d19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT12_INT_MID_SEL"
      sgroup "PBS_CLIENT12_INT_MID_SEL (at 0x7d1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT12_INT_PRIORITY"
      sgroup "PBS_CLIENT12_INT_PRIORITY (at 0x7d1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_TRIG_CFG"
      sgroup "PBS_CLIENT12_TRIG_CFG (at 0x7d40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT12_TRIG_CTL"
      sgroup "PBS_CLIENT12_TRIG_CTL (at 0x7d42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_EN_CTL"
      sgroup "PBS_CLIENT12_EN_CTL (at 0x7d46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_SEC_ACCESS"
      sgroup "PBS_CLIENT12_SEC_ACCESS (at 0x7dd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL1 (at 0x7dd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL2 (at 0x7dd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL3 (at 0x7dda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL4 (at 0x7ddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST1"
      sgroup "PBS_CLIENT12_INT_TEST1 (at 0x7de0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST_VAL"
      sgroup "PBS_CLIENT12_INT_TEST_VAL (at 0x7de1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        set &access:&cmd_addr %l 0x807de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT13"
  tree "PBS_CLIENT13"
    tree "PBS_CLIENT13_REVISION1"
      sgroup "PBS_CLIENT13_REVISION1 (at 0x7e00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION2"
      sgroup "PBS_CLIENT13_REVISION2 (at 0x7e01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION3"
      sgroup "PBS_CLIENT13_REVISION3 (at 0x7e02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION4"
      sgroup "PBS_CLIENT13_REVISION4 (at 0x7e03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_PERPH_TYPE"
      sgroup "PBS_CLIENT13_PERPH_TYPE (at 0x7e04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT13_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT13_PERPH_SUBTYPE (at 0x7e05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT13_STATUS0"
      sgroup "PBS_CLIENT13_STATUS0 (at 0x7e08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_STATUS1"
      sgroup "PBS_CLIENT13_STATUS1 (at 0x7e09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT13_INT_RT_STS"
      sgroup "PBS_CLIENT13_INT_RT_STS (at 0x7e10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT13_INT_SET_TYPE"
      sgroup "PBS_CLIENT13_INT_SET_TYPE (at 0x7e11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT13_INT_POLARITY_HIGH (at 0x7e12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT13_INT_POLARITY_LOW (at 0x7e13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT13_INT_LATCHED_CLR (at 0x7e14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_INT_EN_SET"
      sgroup "PBS_CLIENT13_INT_EN_SET (at 0x7e15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_EN_CLR"
      sgroup "PBS_CLIENT13_INT_EN_CLR (at 0x7e16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_STS"
      sgroup "PBS_CLIENT13_INT_LATCHED_STS (at 0x7e18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT13_INT_PENDING_STS"
      sgroup "PBS_CLIENT13_INT_PENDING_STS (at 0x7e19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT13_INT_MID_SEL"
      sgroup "PBS_CLIENT13_INT_MID_SEL (at 0x7e1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT13_INT_PRIORITY"
      sgroup "PBS_CLIENT13_INT_PRIORITY (at 0x7e1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_TRIG_CFG"
      sgroup "PBS_CLIENT13_TRIG_CFG (at 0x7e40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT13_TRIG_CTL"
      sgroup "PBS_CLIENT13_TRIG_CTL (at 0x7e42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_EN_CTL"
      sgroup "PBS_CLIENT13_EN_CTL (at 0x7e46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        set &access:&cmd_addr %l 0x807e460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x7e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
