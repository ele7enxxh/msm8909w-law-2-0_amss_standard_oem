      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_MID_SEL"
      sgroup "VADC3_MDM_INT_MID_SEL (at 0x321a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_MDM_INT_PRIORITY"
      sgroup "VADC3_MDM_INT_PRIORITY (at 0x321b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_MDM_MODE_CTL"
      sgroup "VADC3_MDM_MODE_CTL (at 0x3240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_MDM_EN_CTL1"
      sgroup "VADC3_MDM_EN_CTL1 (at 0x3246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_MDM_ADC_CH_SEL_CTL"
      sgroup "VADC3_MDM_ADC_CH_SEL_CTL (at 0x3248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_MDM_ADC_DIG_PARAM"
      sgroup "VADC3_MDM_ADC_DIG_PARAM (at 0x3250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_MDM_HW_SETTLE_DELAY"
      sgroup "VADC3_MDM_HW_SETTLE_DELAY (at 0x3251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_MDM_CONV_REQ"
      sgroup "VADC3_MDM_CONV_REQ (at 0x3252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_MDM_CONV_SEQ_CTL"
      sgroup "VADC3_MDM_CONV_SEQ_CTL (at 0x3254)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_MDM_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_MDM_CONV_SEQ_TRIG_CTL (at 0x3255)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_CTL"
      sgroup "VADC3_MDM_MEAS_INTERVAL_CTL (at 0x3257)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_MDM_MEAS_INTERVAL_OP_CTL (at 0x3259)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_MDM_FAST_AVG_CTL"
      sgroup "VADC3_MDM_FAST_AVG_CTL (at 0x325a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_MDM_FAST_AVG_EN"
      sgroup "VADC3_MDM_FAST_AVG_EN (at 0x325b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_MDM_LOW_THR0"
      sgroup "VADC3_MDM_LOW_THR0 (at 0x325c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_MDM_LOW_THR1"
      sgroup "VADC3_MDM_LOW_THR1 (at 0x325d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR0"
      sgroup "VADC3_MDM_HIGH_THR0 (at 0x325e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR1"
      sgroup "VADC3_MDM_HIGH_THR1 (at 0x325f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_MDM_DATA0"
      sgroup "VADC3_MDM_DATA0 (at 0x3260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_MDM_DATA1"
      sgroup "VADC3_MDM_DATA1 (at 0x3261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR0"
      sgroup "VADC3_MDM_MIN_LOW_THR0 (at 0x3262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR1"
      sgroup "VADC3_MDM_MIN_LOW_THR1 (at 0x3263)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_MDM_MIN_DATA0"
      sgroup "VADC3_MDM_MIN_DATA0 (at 0x3266)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_MDM_MIN_DATA1"
      sgroup "VADC3_MDM_MIN_DATA1 (at 0x3267)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_MDM_SEC_ACCESS"
      sgroup "VADC3_MDM_SEC_ACCESS (at 0x32d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL1"
      sgroup "VADC3_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL2"
      sgroup "VADC3_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL3"
      sgroup "VADC3_MDM_PERPH_RESET_CTL3 (at 0x32da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL4"
      sgroup "VADC3_MDM_PERPH_RESET_CTL4 (at 0x32db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST1"
      sgroup "VADC3_MDM_INT_TEST1 (at 0x32e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST_VAL"
      sgroup "VADC3_MDM_INT_TEST_VAL (at 0x32e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_MDM_TEST6_DTEST"
      sgroup "VADC3_MDM_TEST6_DTEST (at 0x32e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VADC3_VBAT"
  tree "VADC3_VBAT"
    tree "VADC3_VBAT_REVISION1"
      sgroup "VADC3_VBAT_REVISION1 (at 0x3500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION2"
      sgroup "VADC3_VBAT_REVISION2 (at 0x3501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION3"
      sgroup "VADC3_VBAT_REVISION3 (at 0x3502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_VBAT_REVISION4"
      sgroup "VADC3_VBAT_REVISION4 (at 0x3503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_VBAT_PERPH_TYPE"
      sgroup "VADC3_VBAT_PERPH_TYPE (at 0x3504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_VBAT_PERPH_SUBTYPE"
      sgroup "VADC3_VBAT_PERPH_SUBTYPE (at 0x3505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_VBAT_STATUS1"
      sgroup "VADC3_VBAT_STATUS1 (at 0x3508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_VBAT_STATUS2"
      sgroup "VADC3_VBAT_STATUS2 (at 0x3509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_RT_STS"
      sgroup "VADC3_VBAT_INT_RT_STS (at 0x3510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_SET_TYPE"
      sgroup "VADC3_VBAT_INT_SET_TYPE (at 0x3511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_VBAT_INT_POLARITY_HIGH"
      sgroup "VADC3_VBAT_INT_POLARITY_HIGH (at 0x3512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_VBAT_INT_POLARITY_LOW"
      sgroup "VADC3_VBAT_INT_POLARITY_LOW (at 0x3513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_VBAT_INT_LATCHED_CLR"
      sgroup "VADC3_VBAT_INT_LATCHED_CLR (at 0x3514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_VBAT_INT_EN_SET"
      sgroup "VADC3_VBAT_INT_EN_SET (at 0x3515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_VBAT_INT_EN_CLR"
      sgroup "VADC3_VBAT_INT_EN_CLR (at 0x3516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_VBAT_INT_LATCHED_STS"
      sgroup "VADC3_VBAT_INT_LATCHED_STS (at 0x3518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_PENDING_STS"
      sgroup "VADC3_VBAT_INT_PENDING_STS (at 0x3519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_MID_SEL"
      sgroup "VADC3_VBAT_INT_MID_SEL (at 0x351a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80351a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x351a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_VBAT_INT_PRIORITY"
      sgroup "VADC3_VBAT_INT_PRIORITY (at 0x351b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80351b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x351b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_VBAT_MODE_CTL"
      sgroup "VADC3_VBAT_MODE_CTL (at 0x3540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_VBAT_EN_CTL1"
      sgroup "VADC3_VBAT_EN_CTL1 (at 0x3546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_VBAT_ADC_CH_SEL_CTL"
      sgroup "VADC3_VBAT_ADC_CH_SEL_CTL (at 0x3548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_VBAT_ADC_DIG_PARAM"
      sgroup "VADC3_VBAT_ADC_DIG_PARAM (at 0x3550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_VBAT_HW_SETTLE_DELAY"
      sgroup "VADC3_VBAT_HW_SETTLE_DELAY (at 0x3551)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_VBAT_CONV_REQ"
      sgroup "VADC3_VBAT_CONV_REQ (at 0x3552)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_VBAT_CONV_SEQ_CTL"
      sgroup "VADC3_VBAT_CONV_SEQ_CTL (at 0x3554)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_VBAT_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_VBAT_CONV_SEQ_TRIG_CTL (at 0x3555)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_VBAT_MEAS_INTERVAL_CTL"
      sgroup "VADC3_VBAT_MEAS_INTERVAL_CTL (at 0x3557)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_VBAT_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_VBAT_MEAS_INTERVAL_OP_CTL (at 0x3559)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_VBAT_FAST_AVG_CTL"
      sgroup "VADC3_VBAT_FAST_AVG_CTL (at 0x355a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_VBAT_FAST_AVG_EN"
      sgroup "VADC3_VBAT_FAST_AVG_EN (at 0x355b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_VBAT_LOW_THR0"
      sgroup "VADC3_VBAT_LOW_THR0 (at 0x355c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_VBAT_LOW_THR1"
      sgroup "VADC3_VBAT_LOW_THR1 (at 0x355d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_VBAT_HIGH_THR0"
      sgroup "VADC3_VBAT_HIGH_THR0 (at 0x355e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_VBAT_HIGH_THR1"
      sgroup "VADC3_VBAT_HIGH_THR1 (at 0x355f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_VBAT_DATA0"
      sgroup "VADC3_VBAT_DATA0 (at 0x3560)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_VBAT_DATA1"
      sgroup "VADC3_VBAT_DATA1 (at 0x3561)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_VBAT_MIN_LOW_THR0"
      sgroup "VADC3_VBAT_MIN_LOW_THR0 (at 0x3562)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_VBAT_MIN_LOW_THR1"
      sgroup "VADC3_VBAT_MIN_LOW_THR1 (at 0x3563)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_VBAT_MIN_DATA0"
      sgroup "VADC3_VBAT_MIN_DATA0 (at 0x3566)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_VBAT_MIN_DATA1"
      sgroup "VADC3_VBAT_MIN_DATA1 (at 0x3567)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_VBAT_SEC_ACCESS"
      sgroup "VADC3_VBAT_SEC_ACCESS (at 0x35d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL1"
      sgroup "VADC3_VBAT_PERPH_RESET_CTL1 (at 0x35d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL2"
      sgroup "VADC3_VBAT_PERPH_RESET_CTL2 (at 0x35d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL3"
      sgroup "VADC3_VBAT_PERPH_RESET_CTL3 (at 0x35da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_VBAT_PERPH_RESET_CTL4"
      sgroup "VADC3_VBAT_PERPH_RESET_CTL4 (at 0x35db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_TEST1"
      sgroup "VADC3_VBAT_INT_TEST1 (at 0x35e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_VBAT_INT_TEST_VAL"
      sgroup "VADC3_VBAT_INT_TEST_VAL (at 0x35e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_VBAT_TEST6_DTEST"
      sgroup "VADC3_VBAT_TEST6_DTEST (at 0x35e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      sgroup "VREFLPDDR_REVISION1 (at 0xa00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      sgroup "VREFLPDDR_REVISION2 (at 0xa01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      sgroup "VREFLPDDR_REVISION3 (at 0xa02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      sgroup "VREFLPDDR_REVISION4 (at 0xa03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      sgroup "VREFLPDDR_PERPH_TYPE (at 0xa04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      sgroup "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      sgroup "VREFLPDDR_STATUS1 (at 0xa08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR_OK                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_VREF_LPDDR2_EN"
      sgroup "VREFLPDDR_VREF_LPDDR2_EN (at 0xa44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      sgroup "VREFLPDDR_EN_CTL1 (at 0xa46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      sgroup "VREFLPDDR_SEC_ACCESS (at 0xad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      sgroup "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      sgroup "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      sgroup "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      sgroup "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      sgroup "VREFLPDDR_TRIM_NUM (at 0xaf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL"
      sgroup "VREFLPDDR_TRIM_VAL (at 0xaf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0 (XO19M_OFF),1 (XO19M_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUFF_CORNER                        = " "0 (LOW_CORNER),1 (HIGH_CORNER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO19M_NOT_FORCED),1 (XO19M_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XO_TIMER_LSB                             = "
    tree.end
    tree "XO_XO_TIMER2"
      sgroup "XO_XO_TIMER2 (at 0x504d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XO_TIMER_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "XO_XO_STEPPER"
      sgroup "XO_XO_STEPPER (at 0x505a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      sgroup "XO_XO_ADJ_FINE (at 0x505c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_XO_ADJ_COARSE"
      sgroup "XO_XO_ADJ_COARSE (at 0x505b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FIXED_CAP_EN1                         = " "0 (FIX_CAP1_DIS),1 (FIX_CAP1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XO_FIXED_CAP_EN2                         = " "0 (FIX_CAP2_DIS),1 (FIX_CAP2_EN)"
    tree.end
    tree "XO_XO_CTL"
      sgroup "XO_XO_CTL (at 0x505e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICTL_MIS4                                = " "0 (XO_BIAS3_DIS),1 (XO_BIAS3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICTL_MIS3                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ICTL_MIS2                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICTL_MIS1                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ICTL_SLP                                 = " "0 (XO_BIAS1_DIS),1 (XO_BIAS1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
    tree.end
    tree "XO_SEC_ACCESS"
      sgroup "XO_SEC_ACCESS (at 0x50d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      sgroup "XO_PERPH_RESET_CTL2 (at 0x50d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      sgroup "XO_PERPH_RESET_CTL3 (at 0x50da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      sgroup "XO_PERPH_RESET_CTL4 (at 0x50db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "XO_TEST1"
      sgroup "XO_TEST1 (at 0x50e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (XO19M),2 (OUTBUG_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      sgroup "XO_TEST2 (at 0x50e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_DIV2_EN                               = " "0 (RF_DIV2_DIS),1 (RF_DIV2_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (DRIVE_RF_NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   XO_38P4_MODE_EN                          = " "0 (XO_19P2_MODE),1 (XO_38P4_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (DRIVE_BB_NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
    tree.end
  tree.end
tree.end

