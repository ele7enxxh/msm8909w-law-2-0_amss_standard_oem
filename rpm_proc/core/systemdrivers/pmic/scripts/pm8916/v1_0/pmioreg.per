        set &access:&cmd_addr %l 0x80a1480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED3),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED7)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED3),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED7)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      sgroup "PBS_CLIENT5_STATUS1 (at 0x7609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      sgroup "PBS_CLIENT6_STATUS1 (at 0x7709)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_50K_EN                             = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0 (LPM),1 (HPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_FSM_CTL"
      sgroup "PON_FSM_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_FSM                                  = "
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM_STATE                                = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      sgroup "PON_PON_CNTL_3_TRIM (at 0x8f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "PWM"
  tree "PWM"
    tree "PWM_REVISION1"
      sgroup "PWM_REVISION1 (at 0x1bc00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM_REVISION2"
      sgroup "PWM_REVISION2 (at 0x1bc01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM_PERPH_TYPE"
      sgroup "PWM_PERPH_TYPE (at 0x1bc04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM_PERPH_SUBTYPE"
      sgroup "PWM_PERPH_SUBTYPE (at 0x1bc05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM_PWM_SIZE_CLK"
      sgroup "PWM_PWM_SIZE_CLK (at 0x1bc41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "PWM_PWM_FREQ_PREDIV_CLK"
      sgroup "PWM_PWM_FREQ_PREDIV_CLK (at 0x1bc42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "PWM_PWM_TYPE_CONFIG"
      sgroup "PWM_PWM_TYPE_CONFIG (at 0x1bc43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "PWM_PWM_VALUE_LSB"
      sgroup "PWM_PWM_VALUE_LSB (at 0x1bc44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "PWM_PWM_VALUE_MSB"
      sgroup "PWM_PWM_VALUE_MSB (at 0x1bc45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "PWM_ENABLE_CONTROL"
      sgroup "PWM_ENABLE_CONTROL (at 0x1bc46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0 (PWM_DISABLE),1 (PWM_ENABLE)"
    tree.end
    tree "PWM_PWM_SYNC"
      sgroup "PWM_PWM_SYNC (at 0x1bc47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0, 1"
    tree.end
    tree "PWM_SEC_ACCESS"
      sgroup "PWM_SEC_ACCESS (at 0x1bcd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM_PERPH_RESET_CTL1"
      sgroup "PWM_PERPH_RESET_CTL1 (at 0x1bcd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PWM_PERPH_RESET_CTL2"
      sgroup "PWM_PERPH_RESET_CTL2 (at 0x1bcd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_PERPH_RESET_CTL3"
      sgroup "PWM_PERPH_RESET_CTL3 (at 0x1bcda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_PERPH_RESET_CTL4"
      sgroup "PWM_PERPH_RESET_CTL4 (at 0x1bcdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PWM_TEST1"
      sgroup "PWM_TEST1 (at 0x1bce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (PWM_OUT),2 (reserved),3 (reserved)"
    tree.end
    tree "PWM_TEST2"
      sgroup "PWM_TEST2 (at 0x1bce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (reserved),2 (PWM_OUT),3 (reserved)"
    tree.end
    tree "PWM_TEST3"
      sgroup "PWM_TEST3 (at 0x1bce4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_GEN_BYPASS                           = " "0 (BYPASS_DISABLE),1 (BYPASS_ENABLE)"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      sgroup "REVID_STATUS1 (at 0x108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OPTION2                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OPTION1                                  = " "0, 1, 2, 3"
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      sgroup "REVID_TEST1 (at 0x1e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      sgroup "RF_CLK1_REVISION1 (at 0x5400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      sgroup "RF_CLK1_REVISION2 (at 0x5401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      sgroup "RF_CLK1_REVISION3 (at 0x5402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      sgroup "RF_CLK1_REVISION4 (at 0x5403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      sgroup "RF_CLK1_PERPH_TYPE (at 0x5404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      sgroup "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      sgroup "RF_CLK1_STATUS1 (at 0x5408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK1_EDGE_CTL1"
      sgroup "RF_CLK1_EDGE_CTL1 (at 0x5443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      sgroup "RF_CLK1_DRV_CTL1 (at 0x5444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_EN_CTL"
      sgroup "RF_CLK1_EN_CTL (at 0x5446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      sgroup "RF_CLK1_PD_CTL (at 0x5448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      sgroup "RF_CLK1_SEC_ACCESS (at 0x54d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      sgroup "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      sgroup "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      sgroup "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      sgroup "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      sgroup "RF_CLK2_REVISION1 (at 0x5500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      sgroup "RF_CLK2_REVISION2 (at 0x5501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      sgroup "RF_CLK2_REVISION3 (at 0x5502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      sgroup "RF_CLK2_REVISION4 (at 0x5503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      sgroup "RF_CLK2_PERPH_TYPE (at 0x5504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      sgroup "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      sgroup "RF_CLK2_STATUS1 (at 0x5508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK2_EDGE_CTL1"
      sgroup "RF_CLK2_EDGE_CTL1 (at 0x5543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      sgroup "RF_CLK2_DRV_CTL1 (at 0x5544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_EN_CTL"
      sgroup "RF_CLK2_EN_CTL (at 0x5546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      sgroup "RF_CLK2_PD_CTL (at 0x5548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      sgroup "RF_CLK2_SEC_ACCESS (at 0x55d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      sgroup "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      sgroup "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      sgroup "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      sgroup "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      sgroup "RTC_ALARM_REVISION1 (at 0x6100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      sgroup "RTC_ALARM_REVISION2 (at 0x6101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      sgroup "RTC_ALARM_PERPH_TYPE (at 0x6104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      sgroup "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      sgroup "RTC_ALARM_STATUS1 (at 0x6108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      sgroup "RTC_ALARM_INT_RT_STS (at 0x6110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      sgroup "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      sgroup "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      sgroup "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      sgroup "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      sgroup "RTC_ALARM_INT_EN_SET (at 0x6115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      sgroup "RTC_ALARM_INT_EN_CLR (at 0x6116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      sgroup "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      sgroup "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      sgroup "RTC_ALARM_INT_MID_SEL (at 0x611a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      sgroup "RTC_ALARM_INT_PRIORITY (at 0x611b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      sgroup "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      sgroup "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      sgroup "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      sgroup "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      sgroup "RTC_ALARM_EN_CTL1 (at 0x6146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      sgroup "RTC_ALARM_ALARM_CLR (at 0x6148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      sgroup "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      sgroup "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      sgroup "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      sgroup "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      sgroup "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      sgroup "RTC_ALARM_INT_TEST1 (at 0x61e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      sgroup "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_RW"
  tree "RTC_RW"
    tree "RTC_RW_REVISION1"
      sgroup "RTC_RW_REVISION1 (at 0x6000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_RW_REVISION2"
      sgroup "RTC_RW_REVISION2 (at 0x6001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_RW_PERPH_TYPE"
      sgroup "RTC_RW_PERPH_TYPE (at 0x6004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_RW_PERPH_SUBTYPE"
      sgroup "RTC_RW_PERPH_SUBTYPE (at 0x6005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_RW_STATUS1"
      sgroup "RTC_RW_STATUS1 (at 0x6008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_RW_INT_RT_STS"
      sgroup "RTC_RW_INT_RT_STS (at 0x6010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_RW_INT_SET_TYPE"
      sgroup "RTC_RW_INT_SET_TYPE (at 0x6011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_RW_INT_POLARITY_HIGH"
      sgroup "RTC_RW_INT_POLARITY_HIGH (at 0x6012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_POLARITY_LOW"
      sgroup "RTC_RW_INT_POLARITY_LOW (at 0x6013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_LATCHED_CLR"
      sgroup "RTC_RW_INT_LATCHED_CLR (at 0x6014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_EN_SET"
      sgroup "RTC_RW_INT_EN_SET (at 0x6015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_RW_INT_EN_CLR"
      sgroup "RTC_RW_INT_EN_CLR (at 0x6016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_LATCHED_STS"
      sgroup "RTC_RW_INT_LATCHED_STS (at 0x6018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_RW_INT_PENDING_STS"
      sgroup "RTC_RW_INT_PENDING_STS (at 0x6019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_RW_INT_MID_SEL"
      sgroup "RTC_RW_INT_MID_SEL (at 0x601a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_RW_INT_PRIORITY"
      sgroup "RTC_RW_INT_PRIORITY (at 0x601b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_RW_WDATA0"
      sgroup "RTC_RW_WDATA0 (at 0x6040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_RW_WDATA1"
      sgroup "RTC_RW_WDATA1 (at 0x6041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_RW_WDATA2"
      sgroup "RTC_RW_WDATA2 (at 0x6042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_RW_WDATA3"
      sgroup "RTC_RW_WDATA3 (at 0x6043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_RW_TIME_ADJ"
      sgroup "RTC_RW_TIME_ADJ (at 0x6044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_RW_EN_CTL1"
      sgroup "RTC_RW_EN_CTL1 (at 0x6046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_RW_RDATA0"
      sgroup "RTC_RW_RDATA0 (at 0x6048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_RW_RDATA1"
      sgroup "RTC_RW_RDATA1 (at 0x6049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_RW_RDATA2"
      sgroup "RTC_RW_RDATA2 (at 0x604a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_RW_RDATA3"
      sgroup "RTC_RW_RDATA3 (at 0x604b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_RW_SEC_ACCESS"
      sgroup "RTC_RW_SEC_ACCESS (at 0x60d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL1"
      sgroup "RTC_RW_PERPH_RESET_CTL1 (at 0x60d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL2"
      sgroup "RTC_RW_PERPH_RESET_CTL2 (at 0x60d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL3"
      sgroup "RTC_RW_PERPH_RESET_CTL3 (at 0x60da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL4"
      sgroup "RTC_RW_PERPH_RESET_CTL4 (at 0x60db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_RW_INT_TEST1"
      sgroup "RTC_RW_INT_TEST1 (at 0x60e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_RW_INT_TEST_VAL"
      sgroup "RTC_RW_INT_TEST_VAL (at 0x60e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_RW_TEST1"
      sgroup "RTC_RW_TEST1 (at 0x60e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      sgroup "RTC_TIMER_REVISION1 (at 0x6200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      sgroup "RTC_TIMER_REVISION2 (at 0x6201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      sgroup "RTC_TIMER_PERPH_TYPE (at 0x6204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      sgroup "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      sgroup "RTC_TIMER_STATUS1 (at 0x6208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      sgroup "RTC_TIMER_INT_RT_STS (at 0x6210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      sgroup "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      sgroup "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      sgroup "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      sgroup "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      sgroup "RTC_TIMER_INT_EN_SET (at 0x6215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      sgroup "RTC_TIMER_INT_EN_CLR (at 0x6216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      sgroup "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      sgroup "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      sgroup "RTC_TIMER_INT_MID_SEL (at 0x621a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      sgroup "RTC_TIMER_INT_PRIORITY (at 0x621b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      sgroup "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      sgroup "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      sgroup "RTC_TIMER_TIMER_MODE (at 0x6245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      sgroup "RTC_TIMER_EN_CTL (at 0x6246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      sgroup "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      sgroup "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      sgroup "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      sgroup "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      sgroup "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      sgroup "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      sgroup "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      sgroup "RTC_TIMER_INT_TEST1 (at 0x62e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      sgroup "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      sgroup "S1_CTRL_STATUS (at 0x11408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      sgroup "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      sgroup "S1_CTRL_PFM_CTL (at 0x11444)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST_OFF),1 (PFM_VOLT_BOOST_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_2MV),1 (PFM_HYST_4MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      sgroup "S1_CTRL_MODE_CTL (at 0x11445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      sgroup "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S1_CTRL_GM_CTL"
      sgroup "S1_CTRL_GM_CTL (at 0x11452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      sgroup "S1_CTRL_RZ_CTL (at 0x11453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      sgroup "S1_CTRL_ISNS_CTRL (at 0x11455)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      sgroup "S1_CTRL_SAW_CTL (at 0x11456)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      sgroup "S1_CTRL_DMAX_CTL (at 0x11458)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      sgroup "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      sgroup "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_VRST),1 (PS_VSET_VRSET_475MV),2 (PS_VSET_VRSET_500MV),3 (PS_VSET_VRSET_525MV),4 (PS_VSET_VRSET_550MV),5 (PS_VSET_VRSET_575MV),6 (PS_VSET_VRSET_600MV),7 (PS_VSET_VRSET_625MV)"
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      sgroup "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      sgroup "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_FT_CTL"
      sgroup "S1_CTRL_FT_CTL (at 0x11462)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S1_CTRL_OCP"
      sgroup "S1_CTRL_OCP (at 0x1146c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      sgroup "S1_CTRL_CTLR_MISC (at 0x1147a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80147a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_OK_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      sgroup "S1_CTRL_CTLR_TEST (at 0x114e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_DVSS),5 (DTEST_SEL_DTEST1_MODE_DTEST2_DVSS),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_7DVSS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      sgroup "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      sgroup "S1_CTRL_CTL_TRIM4 (at 0x114f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      sgroup "S1_FREQ_CLK_ENABLE (at 0x11646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      sgroup "S1_FREQ_CLK_PHASE (at 0x11651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      sgroup "S1_FREQ_GANG_CTL1 (at 0x116c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      sgroup "S1_FREQ_GANG_CTL2 (at 0x116c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      sgroup "S1_FREQ_TEST1 (at 0x116e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_INT_RT_STS"
      sgroup "S1_PS_INT_RT_STS (at 0x11510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_SET_TYPE"
      sgroup "S1_PS_INT_SET_TYPE (at 0x11511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_POLARITY_HIGH"
      sgroup "S1_PS_INT_POLARITY_HIGH (at 0x11512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_POLARITY_LOW"
      sgroup "S1_PS_INT_POLARITY_LOW (at 0x11513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_LATCHED_CLR"
      sgroup "S1_PS_INT_LATCHED_CLR (at 0x11514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_EN_SET"
      sgroup "S1_PS_INT_EN_SET (at 0x11515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_EN_CLR"
      sgroup "S1_PS_INT_EN_CLR (at 0x11516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_LATCHED_STS"
      sgroup "S1_PS_INT_LATCHED_STS (at 0x11518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_PENDING_STS"
      sgroup "S1_PS_INT_PENDING_STS (at 0x11519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_INT_MID_SEL"
      sgroup "S1_PS_INT_MID_SEL (at 0x1151a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80151a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x151a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_PS_INT_PRIORITY"
      sgroup "S1_PS_INT_PRIORITY (at 0x1151b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80151b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x151b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_S3_S4_2700MA_S1_S2_4500MA),1 (CURRENT_LIM_PWM_SEL_S3_S4_2400MA_S1_S2_4000MA),2 (CURRENT_LIM_PWM_SEL_S3_S4_2100MA_S1_S2_3500MA),3 (CURRENT_LIM_PWM_SEL_S3_S4_1800MA_S1_S2_3000MA),4 (CURRENT_LIM_PWM_SEL_S3_S4_1500MA_S1_S2_2500MA),5 (CURRENT_LIM_PWM_SEL_S3_S4_1200MA_S1_S2_2000MA),6 (CURRENT_LIM_PWM_SEL_S3_S4_900MA_S1_S2_1500MA),7 (CURRENT_LIM_PWM_SEL_S3_S4_600MA_S1_S2_1000MA)"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_800MA),1 (CURRENT_LIM_SEL_700MA),2 (CURRENT_LIM_SEL_600MA),3 (CURRENT_LIM_SEL_500MA),4 (CURRENT_LIM_SEL_400MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_200MA),7 (CURRENT_LIM_SEL_100MA)"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      sgroup "S1_PS_SOFT_START_CTL (at 0x1154c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_30US),1 (SOFT_START_ILIM_STEP_DLY_FAST_60US_NORMAL_120US)"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      sgroup "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      sgroup "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS)"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      sgroup "S1_PS_BLNK_TIME_CTL (at 0x11573)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S1_PS_INZERO_CTL"
      sgroup "S1_PS_INZERO_CTL (at 0x11574)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S1_PS_DYNAMIC_DRIVER_EN"
      sgroup "S1_PS_DYNAMIC_DRIVER_EN (at 0x11575)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DYNAMIC_DRIVER_EN                        = " "0 (DISABLE_DYNAMIC_DRIVER),1 (ENABLE_DYNAMIC_DRIVER)"
    tree.end
    tree "S1_PS_IPLIMIT_TEST_EN"
      sgroup "S1_PS_IPLIMIT_TEST_EN (at 0x11576)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIMIT_TEST_EN                          = " "0 (NORMAL_OPERATION),1 (CHANGE_MIRROR_RATIO_TO_MINIMUM)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      sgroup "S1_PS_PWR_STG_MISC (at 0x11579)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S1_PS_HCINT_EN"
      sgroup "S1_PS_HCINT_EN (at 0x11580)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HCINT_EN                                 = " "0 (INT_DISABLE),1 (INT_ENABLE)"
    tree.end
    tree "S1_PS_HCINT_CONTROL"
      sgroup "S1_PS_HCINT_CONTROL (at 0x11581)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SET_WINDOW_WIDTH                         = " "0 (COUNT4),1 (COUNT8)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESET_WINDOW_WIDTH                       = " "0 (COUNT4RESET),1 (COUNT8RESET)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INT2_CUR_THRESHOLD                       = " "0 (RATED_CURRENT_90PCT),1 (RATED_CURRENT_80PCT),2 (RATED_CURRENT_70PCT),3 (RATED_CURRENT_60PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT1_CUR_THRESHOLD                       = " "0 (RATED_CURRENT_70PCT),1 (RATED_CURRENT_60PCT),2 (RATED_CURRENT_50PCT),3 (RATED_CURRENT_40PCT)"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_INT_TEST1"
      sgroup "S1_PS_INT_TEST1 (at 0x115e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_PS_INT_TEST_VAL"
      sgroup "S1_PS_INT_TEST_VAL (at 0x115e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2_TEST_VAL               = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1_TEST_VAL               = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      sgroup "S1_PS_FORCE_FET_TEST (at 0x115e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      sgroup "S1_PS_PWR_STG_TEST (at 0x115e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_HCINT1),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_HCINT2),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_HCINT1_COMP),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_HCINT2_COMP),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      sgroup "S1_PS_PS_TRIM1 (at 0x115f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      sgroup "S1_PS_PS_TRIM2 (at 0x115f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_HCINT_TRIM"
      sgroup "S1_PS_HCINT_TRIM (at 0x115f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCINT_COMP2_TRIM                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HCINT_COMP1_TRIM                         = "
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      sgroup "S2_CTRL_REVISION1 (at 0x11700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      sgroup "S2_CTRL_REVISION2 (at 0x11701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      sgroup "S2_CTRL_REVISION3 (at 0x11702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      sgroup "S2_CTRL_REVISION4 (at 0x11703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      sgroup "S2_CTRL_PERPH_TYPE (at 0x11704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      sgroup "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS"
      sgroup "S2_CTRL_STATUS (at 0x11708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      sgroup "S2_CTRL_INT_RT_STS (at 0x11710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      sgroup "S2_CTRL_INT_SET_TYPE (at 0x11711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      sgroup "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      sgroup "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      sgroup "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      sgroup "S2_CTRL_INT_EN_SET (at 0x11715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      sgroup "S2_CTRL_INT_EN_CLR (at 0x11716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      sgroup "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      sgroup "S2_CTRL_INT_PENDING_STS (at 0x11719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      sgroup "S2_CTRL_INT_MID_SEL (at 0x1171a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      sgroup "S2_CTRL_INT_PRIORITY (at 0x1171b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      sgroup "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S2_CTRL_PFM_CTL"
      sgroup "S2_CTRL_PFM_CTL (at 0x11744)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST_OFF),1 (PFM_VOLT_BOOST_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_2MV),1 (PFM_HYST_4MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      sgroup "S2_CTRL_MODE_CTL (at 0x11745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      sgroup "S2_CTRL_EN_CTL (at 0x11746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      sgroup "S2_CTRL_PD_CTL (at 0x11748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S2_CTRL_COMP_CAP_CTL"
      sgroup "S2_CTRL_COMP_CAP_CTL (at 0x11751)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S2_CTRL_GM_CTL"
      sgroup "S2_CTRL_GM_CTL (at 0x11752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S2_CTRL_RZ_CTL"
      sgroup "S2_CTRL_RZ_CTL (at 0x11753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S2_CTRL_ISNS_CTRL"
      sgroup "S2_CTRL_ISNS_CTRL (at 0x11755)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S2_CTRL_SAW_CTL"
      sgroup "S2_CTRL_SAW_CTL (at 0x11756)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S2_CTRL_DMAX_CTL"
      sgroup "S2_CTRL_DMAX_CTL (at 0x11758)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S2_CTRL_PULSE_SKIP_CTL"
      sgroup "S2_CTRL_PULSE_SKIP_CTL (at 0x11759)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
    tree.end
    tree "S2_CTRL_PULSE_SKIP_THRES"
      sgroup "S2_CTRL_PULSE_SKIP_THRES (at 0x1175a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_VRST),1 (PS_VSET_VRSET_475MV),2 (PS_VSET_VRSET_500MV),3 (PS_VSET_VRSET_525MV),4 (PS_VSET_VRSET_550MV),5 (PS_VSET_VRSET_575MV),6 (PS_VSET_VRSET_600MV),7 (PS_VSET_VRSET_625MV)"
    tree.end
    tree "S2_CTRL_STEPPER_SS_CTL"
      sgroup "S2_CTRL_STEPPER_SS_CTL (at 0x11760)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_STEPPER_VS_CTL"
      sgroup "S2_CTRL_STEPPER_VS_CTL (at 0x11761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_FT_CTL"
      sgroup "S2_CTRL_FT_CTL (at 0x11762)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S2_CTRL_OCP"
      sgroup "S2_CTRL_OCP (at 0x1176c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S2_CTRL_CTLR_MISC"
      sgroup "S2_CTRL_CTLR_MISC (at 0x1177a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80177a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x177a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      sgroup "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      sgroup "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      sgroup "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      sgroup "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      sgroup "S2_CTRL_INT_TEST1 (at 0x117e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      sgroup "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_OK_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S2_CTRL_CTLR_TEST"
      sgroup "S2_CTRL_CTLR_TEST (at 0x117e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_DVSS),5 (DTEST_SEL_DTEST1_MODE_DTEST2_DVSS),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_7DVSS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      sgroup "S2_CTRL_TRIM_NUM (at 0x117f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_CTRL_CTL_TRIM1"
      sgroup "S2_CTRL_CTL_TRIM1 (at 0x117f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S2_CTRL_CTL_TRIM4"
      sgroup "S2_CTRL_CTL_TRIM4 (at 0x117f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      sgroup "S2_FREQ_REVISION1 (at 0x11900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      sgroup "S2_FREQ_REVISION2 (at 0x11901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      sgroup "S2_FREQ_PERPH_TYPE (at 0x11904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      sgroup "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      sgroup "S2_FREQ_CLK_ENABLE (at 0x11946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      sgroup "S2_FREQ_CLK_DIV (at 0x11950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      sgroup "S2_FREQ_CLK_PHASE (at 0x11951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      sgroup "S2_FREQ_GANG_CTL1 (at 0x119c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      sgroup "S2_FREQ_GANG_CTL2 (at 0x119c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      sgroup "S2_FREQ_SEC_ACCESS (at 0x119d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      sgroup "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      sgroup "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      sgroup "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      sgroup "S2_FREQ_TEST1 (at 0x119e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      sgroup "S2_PS_REVISION1 (at 0x11800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      sgroup "S2_PS_REVISION2 (at 0x11801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      sgroup "S2_PS_REVISION3 (at 0x11802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      sgroup "S2_PS_REVISION4 (at 0x11803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      sgroup "S2_PS_PERPH_TYPE (at 0x11804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      sgroup "S2_PS_PERPH_SUBTYPE (at 0x11805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_INT_RT_STS"
      sgroup "S2_PS_INT_RT_STS (at 0x11810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_SET_TYPE"
      sgroup "S2_PS_INT_SET_TYPE (at 0x11811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_POLARITY_HIGH"
      sgroup "S2_PS_INT_POLARITY_HIGH (at 0x11812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_POLARITY_LOW"
      sgroup "S2_PS_INT_POLARITY_LOW (at 0x11813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_LATCHED_CLR"
      sgroup "S2_PS_INT_LATCHED_CLR (at 0x11814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_EN_SET"
      sgroup "S2_PS_INT_EN_SET (at 0x11815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_EN_CLR"
      sgroup "S2_PS_INT_EN_CLR (at 0x11816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_LATCHED_STS"
      sgroup "S2_PS_INT_LATCHED_STS (at 0x11818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_PENDING_STS"
      sgroup "S2_PS_INT_PENDING_STS (at 0x11819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2                        = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1                        = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_INT_MID_SEL"
      sgroup "S2_PS_INT_MID_SEL (at 0x1181a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80181a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x181a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S2_PS_INT_PRIORITY"
      sgroup "S2_PS_INT_PRIORITY (at 0x1181b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80181b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x181b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S2_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S2_PS_PWM_CURRENT_LIM_CTL (at 0x1184a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_S3_S4_2700MA_S1_S2_4500MA),1 (CURRENT_LIM_PWM_SEL_S3_S4_2400MA_S1_S2_4000MA),2 (CURRENT_LIM_PWM_SEL_S3_S4_2100MA_S1_S2_3500MA),3 (CURRENT_LIM_PWM_SEL_S3_S4_1800MA_S1_S2_3000MA),4 (CURRENT_LIM_PWM_SEL_S3_S4_1500MA_S1_S2_2500MA),5 (CURRENT_LIM_PWM_SEL_S3_S4_1200MA_S1_S2_2000MA),6 (CURRENT_LIM_PWM_SEL_S3_S4_900MA_S1_S2_1500MA),7 (CURRENT_LIM_PWM_SEL_S3_S4_600MA_S1_S2_1000MA)"
    tree.end
    tree "S2_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S2_PS_PFM_CURRENT_LIM_CTL (at 0x1184b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_800MA),1 (CURRENT_LIM_SEL_700MA),2 (CURRENT_LIM_SEL_600MA),3 (CURRENT_LIM_SEL_500MA),4 (CURRENT_LIM_SEL_400MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_200MA),7 (CURRENT_LIM_SEL_100MA)"
    tree.end
    tree "S2_PS_SOFT_START_CTL"
      sgroup "S2_PS_SOFT_START_CTL (at 0x1184c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_30US),1 (SOFT_START_ILIM_STEP_DLY_FAST_60US_NORMAL_120US)"
    tree.end
    tree "S2_PS_SWITCH_SIZE_CTL"
      sgroup "S2_PS_SWITCH_SIZE_CTL (at 0x11870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S2_PS_DEAD_TIME_CTRL2"
      sgroup "S2_PS_DEAD_TIME_CTRL2 (at 0x11872)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS)"
    tree.end
    tree "S2_PS_BLNK_TIME_CTL"
      sgroup "S2_PS_BLNK_TIME_CTL (at 0x11873)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S2_PS_INZERO_CTL"
      sgroup "S2_PS_INZERO_CTL (at 0x11874)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S2_PS_DYNAMIC_DRIVER_EN"
      sgroup "S2_PS_DYNAMIC_DRIVER_EN (at 0x11875)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DYNAMIC_DRIVER_EN                        = " "0 (DISABLE_DYNAMIC_DRIVER),1 (ENABLE_DYNAMIC_DRIVER)"
    tree.end
    tree "S2_PS_IPLIMIT_TEST_EN"
      sgroup "S2_PS_IPLIMIT_TEST_EN (at 0x11876)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIMIT_TEST_EN                          = " "0 (NORMAL_OPERATION),1 (CHANGE_MIRROR_RATIO_TO_MINIMUM)"
    tree.end
    tree "S2_PS_PWR_STG_MISC"
      sgroup "S2_PS_PWR_STG_MISC (at 0x11879)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S2_PS_HCINT_EN"
      sgroup "S2_PS_HCINT_EN (at 0x11880)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HCINT_EN                                 = " "0 (INT_DISABLE),1 (INT_ENABLE)"
    tree.end
    tree "S2_PS_HCINT_CONTROL"
      sgroup "S2_PS_HCINT_CONTROL (at 0x11881)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SET_WINDOW_WIDTH                         = " "0 (COUNT4),1 (COUNT8)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESET_WINDOW_WIDTH                       = " "0 (COUNT4RESET),1 (COUNT8RESET)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INT2_CUR_THRESHOLD                       = " "0 (RATED_CURRENT_90PCT),1 (RATED_CURRENT_80PCT),2 (RATED_CURRENT_70PCT),3 (RATED_CURRENT_60PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT1_CUR_THRESHOLD                       = " "0 (RATED_CURRENT_70PCT),1 (RATED_CURRENT_60PCT),2 (RATED_CURRENT_50PCT),3 (RATED_CURRENT_40PCT)"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      sgroup "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      sgroup "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      sgroup "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_PS_INT_TEST1"
      sgroup "S2_PS_INT_TEST1 (at 0x118e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_PS_INT_TEST_VAL"
      sgroup "S2_PS_INT_TEST_VAL (at 0x118e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HIGH_CURRENT_INT2_TEST_VAL               = " "0 (HIGH_CURRENT_INT2_FALSE),1 (HIGH_CURRENT_INT2_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_CURRENT_INT1_TEST_VAL               = " "0 (HIGH_CURRENT_INT1_FALSE),1 (HIGH_CURRENT_INT1_TRUE)"
    tree.end
    tree "S2_PS_FORCE_FET_TEST"
      sgroup "S2_PS_FORCE_FET_TEST (at 0x118e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S2_PS_PWR_STG_TEST"
      sgroup "S2_PS_PWR_STG_TEST (at 0x118e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_HCINT1),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_HCINT2),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_HCINT1_COMP),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_HCINT2_COMP),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_PS_TRIM_NUM"
      sgroup "S2_PS_TRIM_NUM (at 0x118f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_PS_PS_TRIM1"
      sgroup "S2_PS_PS_TRIM1 (at 0x118f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S2_PS_PS_TRIM2"
      sgroup "S2_PS_PS_TRIM2 (at 0x118f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_HCINT_TRIM"
      sgroup "S2_PS_HCINT_TRIM (at 0x118f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCINT_COMP2_TRIM                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HCINT_COMP1_TRIM                         = "
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      sgroup "S3_CTRL_REVISION1 (at 0x11a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      sgroup "S3_CTRL_REVISION2 (at 0x11a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      sgroup "S3_CTRL_REVISION3 (at 0x11a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      sgroup "S3_CTRL_REVISION4 (at 0x11a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      sgroup "S3_CTRL_PERPH_TYPE (at 0x11a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      sgroup "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      sgroup "S3_CTRL_STATUS (at 0x11a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      sgroup "S3_CTRL_INT_RT_STS (at 0x11a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      sgroup "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      sgroup "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      sgroup "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      sgroup "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      sgroup "S3_CTRL_INT_EN_SET (at 0x11a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      sgroup "S3_CTRL_INT_EN_CLR (at 0x11a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      sgroup "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      sgroup "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      sgroup "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      sgroup "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      sgroup "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      sgroup "S3_CTRL_PFM_CTL (at 0x11a44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST_OFF),1 (PFM_VOLT_BOOST_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_2MV),1 (PFM_HYST_4MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      sgroup "S3_CTRL_MODE_CTL (at 0x11a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      sgroup "S3_CTRL_EN_CTL (at 0x11a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      sgroup "S3_CTRL_PD_CTL (at 0x11a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      sgroup "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S3_CTRL_GM_CTL"
      sgroup "S3_CTRL_GM_CTL (at 0x11a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      sgroup "S3_CTRL_RZ_CTL (at 0x11a53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      sgroup "S3_CTRL_ISNS_CTRL (at 0x11a55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      sgroup "S3_CTRL_SAW_CTL (at 0x11a56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      sgroup "S3_CTRL_DMAX_CTL (at 0x11a58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      sgroup "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      sgroup "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_VRST),1 (PS_VSET_VRSET_475MV),2 (PS_VSET_VRSET_500MV),3 (PS_VSET_VRSET_525MV),4 (PS_VSET_VRSET_550MV),5 (PS_VSET_VRSET_575MV),6 (PS_VSET_VRSET_600MV),7 (PS_VSET_VRSET_625MV)"
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      sgroup "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      sgroup "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_FT_CTL"
      sgroup "S3_CTRL_FT_CTL (at 0x11a62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S3_CTRL_OCP"
      sgroup "S3_CTRL_OCP (at 0x11a6c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a6c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      sgroup "S3_CTRL_CTLR_MISC (at 0x11a7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      sgroup "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      sgroup "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      sgroup "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      sgroup "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      sgroup "S3_CTRL_INT_TEST1 (at 0x11ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      sgroup "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_OK_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      sgroup "S3_CTRL_CTLR_TEST (at 0x11ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_DVSS),5 (DTEST_SEL_DTEST1_MODE_DTEST2_DVSS),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_7DVSS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      sgroup "S3_CTRL_TRIM_NUM (at 0x11af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      sgroup "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      sgroup "S3_CTRL_CTL_TRIM4 (at 0x11af2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      sgroup "S3_FREQ_REVISION1 (at 0x11c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      sgroup "S3_FREQ_REVISION2 (at 0x11c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      sgroup "S3_FREQ_PERPH_TYPE (at 0x11c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      sgroup "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      sgroup "S3_FREQ_CLK_ENABLE (at 0x11c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      sgroup "S3_FREQ_CLK_DIV (at 0x11c50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      sgroup "S3_FREQ_CLK_PHASE (at 0x11c51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      sgroup "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      sgroup "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      sgroup "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      sgroup "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      sgroup "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      sgroup "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      sgroup "S3_FREQ_TEST1 (at 0x11ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      sgroup "S3_PS_REVISION1 (at 0x11b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      sgroup "S3_PS_REVISION2 (at 0x11b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      sgroup "S3_PS_REVISION3 (at 0x11b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      sgroup "S3_PS_REVISION4 (at 0x11b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      sgroup "S3_PS_PERPH_TYPE (at 0x11b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      sgroup "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_S3_S4_2700MA_S1_S2_4500MA),1 (CURRENT_LIM_PWM_SEL_S3_S4_2400MA_S1_S2_4000MA),2 (CURRENT_LIM_PWM_SEL_S3_S4_2100MA_S1_S2_3500MA),3 (CURRENT_LIM_PWM_SEL_S3_S4_1800MA_S1_S2_3000MA),4 (CURRENT_LIM_PWM_SEL_S3_S4_1500MA_S1_S2_2500MA),5 (CURRENT_LIM_PWM_SEL_S3_S4_1200MA_S1_S2_2000MA),6 (CURRENT_LIM_PWM_SEL_S3_S4_900MA_S1_S2_1500MA),7 (CURRENT_LIM_PWM_SEL_S3_S4_600MA_S1_S2_1000MA)"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_800MA),1 (CURRENT_LIM_SEL_700MA),2 (CURRENT_LIM_SEL_600MA),3 (CURRENT_LIM_SEL_500MA),4 (CURRENT_LIM_SEL_400MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_200MA),7 (CURRENT_LIM_SEL_100MA)"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      sgroup "S3_PS_SOFT_START_CTL (at 0x11b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_30US),1 (SOFT_START_ILIM_STEP_DLY_FAST_60US_NORMAL_120US)"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      sgroup "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      sgroup "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS)"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      sgroup "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S3_PS_INZERO_CTL"
      sgroup "S3_PS_INZERO_CTL (at 0x11b74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S3_PS_IPLIMIT_TEST_EN"
      sgroup "S3_PS_IPLIMIT_TEST_EN (at 0x11b76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIMIT_TEST_EN                          = " "0 (NORMAL_OPERATION),1 (CHANGE_MIRROR_RATIO_TO_MINIMUM)"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      sgroup "S3_PS_PWR_STG_MISC (at 0x11b79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      sgroup "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      sgroup "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      sgroup "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      sgroup "S3_PS_FORCE_FET_TEST (at 0x11be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      sgroup "S3_PS_PWR_STG_TEST (at 0x11be4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_PS_TRIM_NUM"
      sgroup "S3_PS_TRIM_NUM (at 0x11bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      sgroup "S3_PS_PS_TRIM1 (at 0x11bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      sgroup "S3_PS_PS_TRIM2 (at 0x11bf2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      sgroup "S4_CTRL_REVISION1 (at 0x11d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      sgroup "S4_CTRL_REVISION2 (at 0x11d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      sgroup "S4_CTRL_REVISION3 (at 0x11d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      sgroup "S4_CTRL_REVISION4 (at 0x11d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      sgroup "S4_CTRL_PERPH_TYPE (at 0x11d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      sgroup "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS"
      sgroup "S4_CTRL_STATUS (at 0x11d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      sgroup "S4_CTRL_INT_RT_STS (at 0x11d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      sgroup "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      sgroup "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      sgroup "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      sgroup "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      sgroup "S4_CTRL_INT_EN_SET (at 0x11d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      sgroup "S4_CTRL_INT_EN_CLR (at 0x11d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      sgroup "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      sgroup "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      sgroup "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      sgroup "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      sgroup "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_PFM_CTL"
      sgroup "S4_CTRL_PFM_CTL (at 0x11d44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST_OFF),1 (PFM_VOLT_BOOST_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_2MV),1 (PFM_HYST_4MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      sgroup "S4_CTRL_MODE_CTL (at 0x11d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      sgroup "S4_CTRL_EN_CTL (at 0x11d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      sgroup "S4_CTRL_PD_CTL (at 0x11d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_COMP_CAP_CTL"
      sgroup "S4_CTRL_COMP_CAP_CTL (at 0x11d51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S4_CTRL_GM_CTL"
      sgroup "S4_CTRL_GM_CTL (at 0x11d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S4_CTRL_RZ_CTL"
      sgroup "S4_CTRL_RZ_CTL (at 0x11d53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S4_CTRL_ISNS_CTRL"
      sgroup "S4_CTRL_ISNS_CTRL (at 0x11d55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S4_CTRL_SAW_CTL"
      sgroup "S4_CTRL_SAW_CTL (at 0x11d56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S4_CTRL_DMAX_CTL"
      sgroup "S4_CTRL_DMAX_CTL (at 0x11d58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_CTL"
      sgroup "S4_CTRL_PULSE_SKIP_CTL (at 0x11d59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_THRES"
      sgroup "S4_CTRL_PULSE_SKIP_THRES (at 0x11d5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_VRST),1 (PS_VSET_VRSET_475MV),2 (PS_VSET_VRSET_500MV),3 (PS_VSET_VRSET_525MV),4 (PS_VSET_VRSET_550MV),5 (PS_VSET_VRSET_575MV),6 (PS_VSET_VRSET_600MV),7 (PS_VSET_VRSET_625MV)"
    tree.end
    tree "S4_CTRL_STEPPER_SS_CTL"
      sgroup "S4_CTRL_STEPPER_SS_CTL (at 0x11d60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_STEPPER_VS_CTL"
      sgroup "S4_CTRL_STEPPER_VS_CTL (at 0x11d61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_FT_CTL"
      sgroup "S4_CTRL_FT_CTL (at 0x11d62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S4_CTRL_OCP"
      sgroup "S4_CTRL_OCP (at 0x11d6c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S4_CTRL_CTLR_MISC"
      sgroup "S4_CTRL_CTLR_MISC (at 0x11d7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      sgroup "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      sgroup "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      sgroup "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      sgroup "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      sgroup "S4_CTRL_INT_TEST1 (at 0x11de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      sgroup "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_OK_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_CTLR_TEST"
      sgroup "S4_CTRL_CTLR_TEST (at 0x11de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_DVSS),5 (DTEST_SEL_DTEST1_MODE_DTEST2_DVSS),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_7DVSS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      sgroup "S4_CTRL_TRIM_NUM (at 0x11df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_CTRL_CTL_TRIM1"
      sgroup "S4_CTRL_CTL_TRIM1 (at 0x11df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S4_CTRL_CTL_TRIM4"
      sgroup "S4_CTRL_CTL_TRIM4 (at 0x11df2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      sgroup "S4_FREQ_REVISION1 (at 0x11f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      sgroup "S4_FREQ_REVISION2 (at 0x11f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      sgroup "S4_FREQ_PERPH_TYPE (at 0x11f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      sgroup "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      sgroup "S4_FREQ_CLK_ENABLE (at 0x11f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      sgroup "S4_FREQ_CLK_DIV (at 0x11f50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      sgroup "S4_FREQ_CLK_PHASE (at 0x11f51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      sgroup "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      sgroup "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      sgroup "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      sgroup "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      sgroup "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      sgroup "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      sgroup "S4_FREQ_TEST1 (at 0x11fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      sgroup "S4_PS_REVISION1 (at 0x11e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      sgroup "S4_PS_REVISION2 (at 0x11e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      sgroup "S4_PS_REVISION3 (at 0x11e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      sgroup "S4_PS_REVISION4 (at 0x11e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      sgroup "S4_PS_PERPH_TYPE (at 0x11e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      sgroup "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PWM_CURRENT_LIM_CTL (at 0x11e4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_S3_S4_2700MA_S1_S2_4500MA),1 (CURRENT_LIM_PWM_SEL_S3_S4_2400MA_S1_S2_4000MA),2 (CURRENT_LIM_PWM_SEL_S3_S4_2100MA_S1_S2_3500MA),3 (CURRENT_LIM_PWM_SEL_S3_S4_1800MA_S1_S2_3000MA),4 (CURRENT_LIM_PWM_SEL_S3_S4_1500MA_S1_S2_2500MA),5 (CURRENT_LIM_PWM_SEL_S3_S4_1200MA_S1_S2_2000MA),6 (CURRENT_LIM_PWM_SEL_S3_S4_900MA_S1_S2_1500MA),7 (CURRENT_LIM_PWM_SEL_S3_S4_600MA_S1_S2_1000MA)"
    tree.end
    tree "S4_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PFM_CURRENT_LIM_CTL (at 0x11e4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_800MA),1 (CURRENT_LIM_SEL_700MA),2 (CURRENT_LIM_SEL_600MA),3 (CURRENT_LIM_SEL_500MA),4 (CURRENT_LIM_SEL_400MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_200MA),7 (CURRENT_LIM_SEL_100MA)"
    tree.end
    tree "S4_PS_SOFT_START_CTL"
      sgroup "S4_PS_SOFT_START_CTL (at 0x11e4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_30US),1 (SOFT_START_ILIM_STEP_DLY_FAST_60US_NORMAL_120US)"
    tree.end
    tree "S4_PS_SWITCH_SIZE_CTL"
      sgroup "S4_PS_SWITCH_SIZE_CTL (at 0x11e70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL2"
      sgroup "S4_PS_DEAD_TIME_CTRL2 (at 0x11e72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS)"
    tree.end
    tree "S4_PS_BLNK_TIME_CTL"
      sgroup "S4_PS_BLNK_TIME_CTL (at 0x11e73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S4_PS_INZERO_CTL"
      sgroup "S4_PS_INZERO_CTL (at 0x11e74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S4_PS_IPLIMIT_TEST_EN"
      sgroup "S4_PS_IPLIMIT_TEST_EN (at 0x11e76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIMIT_TEST_EN                          = " "0 (NORMAL_OPERATION),1 (CHANGE_MIRROR_RATIO_TO_MINIMUM)"
    tree.end
    tree "S4_PS_PWR_STG_MISC"
      sgroup "S4_PS_PWR_STG_MISC (at 0x11e79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      sgroup "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      sgroup "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      sgroup "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_PS_FORCE_FET_TEST"
      sgroup "S4_PS_FORCE_FET_TEST (at 0x11ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S4_PS_PWR_STG_TEST"
      sgroup "S4_PS_PWR_STG_TEST (at 0x11ee4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_PS_TRIM_NUM"
      sgroup "S4_PS_TRIM_NUM (at 0x11ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_PS_PS_TRIM1"
      sgroup "S4_PS_PS_TRIM1 (at 0x11ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S4_PS_PS_TRIM2"
      sgroup "S4_PS_PS_TRIM2 (at 0x11ef2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      sgroup "SLEEP_CLK1_REVISION1 (at 0x5a00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      sgroup "SLEEP_CLK1_REVISION2 (at 0x5a01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      sgroup "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      sgroup "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_STATUS1"
      sgroup "SLEEP_CLK1_STATUS1 (at 0x5a08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_OK                               = " "0 (SLP_CLK_BUFFER_OFF),1 (SLP_CLK_BUFFER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (XO_32K),1 (EXT_32K),2 (CALRC),3 (LFRC),4 (RC19M_DIV),5 (XO19M_DIV),6 (RESERVED),7 (reserved)"
    tree.end
    tree "SLEEP_CLK1_INT_RT_STS"
      sgroup "SLEEP_CLK1_INT_RT_STS (at 0x5a10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_RT_STS                    = " "0 (XO32K_NOT_HALT),1 (XO32K_HALT)"
    tree.end
    tree "SLEEP_CLK1_INT_SET_TYPE"
      sgroup "SLEEP_CLK1_INT_SET_TYPE (at 0x5a11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_HIGH"
      sgroup "SLEEP_CLK1_INT_POLARITY_HIGH (at 0x5a12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_LOW"
      sgroup "SLEEP_CLK1_INT_POLARITY_LOW (at 0x5a13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_CLR"
      sgroup "SLEEP_CLK1_INT_LATCHED_CLR (at 0x5a14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_EN_SET"
      sgroup "SLEEP_CLK1_INT_EN_SET (at 0x5a15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_EN_CLR"
      sgroup "SLEEP_CLK1_INT_EN_CLR (at 0x5a16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_STS"
      sgroup "SLEEP_CLK1_INT_LATCHED_STS (at 0x5a18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "SLEEP_CLK1_INT_PENDING_STS"
      sgroup "SLEEP_CLK1_INT_PENDING_STS (at 0x5a19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "SLEEP_CLK1_INT_MID_SEL"
      sgroup "SLEEP_CLK1_INT_MID_SEL (at 0x5a1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SLEEP_CLK1_INT_PRIORITY"
      sgroup "SLEEP_CLK1_INT_PRIORITY (at 0x5a1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      sgroup "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_HALT_CTL"
      sgroup "SLEEP_CLK1_HALT_CTL (at 0x5a45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_HALT_EN                            = " "0 (XO32K_HALT_DISABLED),1 (XO32K_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO32K_OSC_HALT                     = " "0 (XO32K_HALT_NOT_FORCED),1 (XO32K_HALT_FORCED)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      sgroup "SLEEP_CLK1_EN_CTL (at 0x5a46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_PAD_EN                           = " "0 (SLP_CLK_BUF_DISABLED),1 (SLP_CLK_BUF_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_SMPL_CTL1"
      sgroup "SLEEP_CLK1_SMPL_CTL1 (at 0x5a48)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SMPL_DELAY                               = " "0 (HALF_SEC),1 (ONE_SEC),2 (ONEANDHALF_SEC),3 (TWO_SEC)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      sgroup "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_EN                                 = " "0 (XO32K_DISABLED),1 (XO32K_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_OSC_SEL2I                          = " "0 (NORMAL_CURRENT),1 (MORE_CURRENT)"
    tree.end
    tree "SLEEP_CLK1_LFRC_CTL"
      sgroup "SLEEP_CLK1_LFRC_CTL (at 0x5a57)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLKS_XVDD_BLEED                          = " "0 (NA_0),1 (NA_200),2 (reserved),3 (NA_600),4 (reserved),5 (reserved),6 (reserved),7 (NA_1600)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      sgroup "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      sgroup "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      sgroup "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      sgroup "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      sgroup "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      sgroup "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805add0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5add0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_TEST1"
      sgroup "SLEEP_CLK1_INT_TEST1 (at 0x5ae0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "SLEEP_CLK1_INT_TEST_VAL"
      sgroup "SLEEP_CLK1_INT_TEST_VAL (at 0x5ae1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TEST_VAL                  = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      sgroup "SLEEP_CLK1_TEST1 (at 0x5ae2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMPL_TRIGGER_SEL                         = " "0 (HIZ),1 (CONNECT_TO_DTEST)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CXVDD_ATEST_EN                           = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      sgroup "TEMP_ALARM_TEST1 (at 0x24e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      sgroup "TEMP_ALARM_TEST2 (at 0x24e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      sgroup "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "VADC1_LC_USR"
  tree "VADC1_LC_USR"
    tree "VADC1_LC_USR_REVISION1"
      sgroup "VADC1_LC_USR_REVISION1 (at 0x3100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_LC_USR_REVISION2"
      sgroup "VADC1_LC_USR_REVISION2 (at 0x3101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_LC_USR_REVISION3"
      sgroup "VADC1_LC_USR_REVISION3 (at 0x3102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_LC_USR_REVISION4"
      sgroup "VADC1_LC_USR_REVISION4 (at 0x3103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_LC_USR_PERPH_TYPE"
      sgroup "VADC1_LC_USR_PERPH_TYPE (at 0x3104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_LC_USR_PERPH_SUBTYPE"
      sgroup "VADC1_LC_USR_PERPH_SUBTYPE (at 0x3105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_LC_USR_STATUS1"
      sgroup "VADC1_LC_USR_STATUS1 (at 0x3108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_LC_USR_STATUS2"
      sgroup "VADC1_LC_USR_STATUS2 (at 0x3109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_RT_STS"
      sgroup "VADC1_LC_USR_INT_RT_STS (at 0x3110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_SET_TYPE"
      sgroup "VADC1_LC_USR_INT_SET_TYPE (at 0x3111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_LC_USR_INT_POLARITY_HIGH"
      sgroup "VADC1_LC_USR_INT_POLARITY_HIGH (at 0x3112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_INT_POLARITY_LOW"
      sgroup "VADC1_LC_USR_INT_POLARITY_LOW (at 0x3113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_INT_LATCHED_CLR"
      sgroup "VADC1_LC_USR_INT_LATCHED_CLR (at 0x3114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_LC_USR_INT_EN_SET"
      sgroup "VADC1_LC_USR_INT_EN_SET (at 0x3115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_LC_USR_INT_EN_CLR"
      sgroup "VADC1_LC_USR_INT_EN_CLR (at 0x3116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_LC_USR_INT_LATCHED_STS"
      sgroup "VADC1_LC_USR_INT_LATCHED_STS (at 0x3118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_PENDING_STS"
      sgroup "VADC1_LC_USR_INT_PENDING_STS (at 0x3119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_MID_SEL"
      sgroup "VADC1_LC_USR_INT_MID_SEL (at 0x311a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_LC_USR_INT_PRIORITY"
      sgroup "VADC1_LC_USR_INT_PRIORITY (at 0x311b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_LC_USR_MODE_CTL"
      sgroup "VADC1_LC_USR_MODE_CTL (at 0x3140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_EN_CTL1"
      sgroup "VADC1_LC_USR_EN_CTL1 (at 0x3146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_ADC_CH_SEL_CTL"
      sgroup "VADC1_LC_USR_ADC_CH_SEL_CTL (at 0x3148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_LC_USR_ADC_DIG_PARAM"
      sgroup "VADC1_LC_USR_ADC_DIG_PARAM (at 0x3150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_LC_USR_HW_SETTLE_DELAY"
      sgroup "VADC1_LC_USR_HW_SETTLE_DELAY (at 0x3151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_LC_USR_CONV_REQ"
      sgroup "VADC1_LC_USR_CONV_REQ (at 0x3152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_LC_USR_CONV_SEQ_CTL"
      sgroup "VADC1_LC_USR_CONV_SEQ_CTL (at 0x3154)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_LC_USR_CONV_SEQ_TRIG_CTL"
      sgroup "VADC1_LC_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_LC_USR_MEAS_INTERVAL_CTL"
      sgroup "VADC1_LC_USR_MEAS_INTERVAL_CTL (at 0x3157)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_LC_USR_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC1_LC_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_FAST_AVG_CTL"
      sgroup "VADC1_LC_USR_FAST_AVG_CTL (at 0x315a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_LC_USR_FAST_AVG_EN"
      sgroup "VADC1_LC_USR_FAST_AVG_EN (at 0x315b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_LOW_THR0"
      sgroup "VADC1_LC_USR_LOW_THR0 (at 0x315c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_LC_USR_LOW_THR1"
      sgroup "VADC1_LC_USR_LOW_THR1 (at 0x315d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_LC_USR_HIGH_THR0"
      sgroup "VADC1_LC_USR_HIGH_THR0 (at 0x315e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_LC_USR_HIGH_THR1"
      sgroup "VADC1_LC_USR_HIGH_THR1 (at 0x315f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_LC_USR_DATA0"
      sgroup "VADC1_LC_USR_DATA0 (at 0x3160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_LC_USR_DATA1"
      sgroup "VADC1_LC_USR_DATA1 (at 0x3161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_LC_USR_MIN_LOW_THR0"
      sgroup "VADC1_LC_USR_MIN_LOW_THR0 (at 0x3162)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC1_LC_USR_MIN_LOW_THR1"
      sgroup "VADC1_LC_USR_MIN_LOW_THR1 (at 0x3163)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC1_LC_USR_MIN_DATA0"
      sgroup "VADC1_LC_USR_MIN_DATA0 (at 0x3166)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC1_LC_USR_MIN_DATA1"
      sgroup "VADC1_LC_USR_MIN_DATA1 (at 0x3167)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC1_LC_USR_SEC_ACCESS"
      sgroup "VADC1_LC_USR_SEC_ACCESS (at 0x31d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_LC_USR_PERPH_RESET_CTL1"
      sgroup "VADC1_LC_USR_PERPH_RESET_CTL1 (at 0x31d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_LC_USR_PERPH_RESET_CTL2"
      sgroup "VADC1_LC_USR_PERPH_RESET_CTL2 (at 0x31d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_LC_USR_PERPH_RESET_CTL3"
      sgroup "VADC1_LC_USR_PERPH_RESET_CTL3 (at 0x31da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_LC_USR_PERPH_RESET_CTL4"
      sgroup "VADC1_LC_USR_PERPH_RESET_CTL4 (at 0x31db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_TEST1"
      sgroup "VADC1_LC_USR_INT_TEST1 (at 0x31e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_LC_USR_INT_TEST_VAL"
      sgroup "VADC1_LC_USR_INT_TEST_VAL (at 0x31e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_LC_USR_TEST1_ADC_ANA_PARAM"
      sgroup "VADC1_LC_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_LC_USR_TEST2_ADC_DIG_PARAM"
      sgroup "VADC1_LC_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_LC_USR_TEST3_ADC_RSV"
      sgroup "VADC1_LC_USR_TEST3_ADC_RSV (at 0x31e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_LC_USR_TEST4_ADC_ATEST"
      sgroup "VADC1_LC_USR_TEST4_ADC_ATEST (at 0x31e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_LC_USR_TEST5_AMUX_ATEST"
      sgroup "VADC1_LC_USR_TEST5_AMUX_ATEST (at 0x31e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_LC_USR_TEST6_DTEST"
      sgroup "VADC1_LC_USR_TEST6_DTEST (at 0x31e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_LC_USR_TRIM_NUM"
      sgroup "VADC1_LC_USR_TRIM_NUM (at 0x31f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_LC_USR_TRIM1_ADC"
      sgroup "VADC1_LC_USR_TRIM1_ADC (at 0x31f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_LC_USR_TRIM1_AMUX"
      sgroup "VADC1_LC_USR_TRIM1_AMUX (at 0x31f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_LC_USR_TRIM2_AMUX"
      sgroup "VADC1_LC_USR_TRIM2_AMUX (at 0x31f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_LC_USR_TRIM4_AMUX"
      sgroup "VADC1_LC_USR_TRIM4_AMUX (at 0x31f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_LC_USR_TRIM5_AMUX"
      sgroup "VADC1_LC_USR_TRIM5_AMUX (at 0x31f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "VADC2_LC_BTM_2"
  tree "VADC2_LC_BTM_2"
    tree "VADC2_LC_BTM_2_REVISION1"
      sgroup "VADC2_LC_BTM_2_REVISION1 (at 0x3400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC2_LC_BTM_2_REVISION2"
      sgroup "VADC2_LC_BTM_2_REVISION2 (at 0x3401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC2_LC_BTM_2_REVISION3"
      sgroup "VADC2_LC_BTM_2_REVISION3 (at 0x3402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC2_LC_BTM_2_REVISION4"
      sgroup "VADC2_LC_BTM_2_REVISION4 (at 0x3403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_TYPE"
      sgroup "VADC2_LC_BTM_2_PERPH_TYPE (at 0x3404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_SUBTYPE"
      sgroup "VADC2_LC_BTM_2_PERPH_SUBTYPE (at 0x3405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC2_LC_BTM_2_STATUS1"
      sgroup "VADC2_LC_BTM_2_STATUS1 (at 0x3408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC2_LC_BTM_2_STATUS2"
      sgroup "VADC2_LC_BTM_2_STATUS2 (at 0x3409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_STATUS_LOW"
      sgroup "VADC2_LC_BTM_2_STATUS_LOW (at 0x340a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80340a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x340a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW                                   = " "0 (M7_LOW_FALSE),1 (M7_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW                                   = " "0 (M6_LOW_FALSE),1 (M6_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW                                   = " "0 (M5_LOW_FALSE),1 (M5_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW                                   = " "0 (M4_LOW_FALSE),1 (M4_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW                                   = " "0 (M3_LOW_FALSE),1 (M3_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW                                   = " "0 (M2_LOW_FALSE),1 (M2_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW                                   = " "0 (M1_LOW_FALSE),1 (M1_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW                                   = " "0 (M0_LOW_FALSE),1 (M0_LOW_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_STATUS_HIGH"
      sgroup "VADC2_LC_BTM_2_STATUS_HIGH (at 0x340b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80340b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x340b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH                                  = " "0 (M7_HIGH_FALSE),1 (M7_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH                                  = " "0 (M6_HIGH_FALSE),1 (M6_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH                                  = " "0 (M5_HIGH_FALSE),1 (M5_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH                                  = " "0 (M4_HIGH_FALSE),1 (M4_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH                                  = " "0 (M3_HIGH_FALSE),1 (M3_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH                                  = " "0 (M2_HIGH_FALSE),1 (M2_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH                                  = " "0 (M1_HIGH_FALSE),1 (M1_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH                                  = " "0 (M0_HIGH_FALSE),1 (M0_HIGH_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_RT_STS"
      sgroup "VADC2_LC_BTM_2_INT_RT_STS (at 0x3410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_SET_TYPE"
      sgroup "VADC2_LC_BTM_2_INT_SET_TYPE (at 0x3411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_POLARITY_HIGH"
      sgroup "VADC2_LC_BTM_2_INT_POLARITY_HIGH (at 0x3412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_POLARITY_LOW"
      sgroup "VADC2_LC_BTM_2_INT_POLARITY_LOW (at 0x3413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_LATCHED_CLR"
      sgroup "VADC2_LC_BTM_2_INT_LATCHED_CLR (at 0x3414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC2_LC_BTM_2_INT_EN_SET"
      sgroup "VADC2_LC_BTM_2_INT_EN_SET (at 0x3415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_EN_CLR"
      sgroup "VADC2_LC_BTM_2_INT_EN_CLR (at 0x3416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_LATCHED_STS"
      sgroup "VADC2_LC_BTM_2_INT_LATCHED_STS (at 0x3418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_PENDING_STS"
      sgroup "VADC2_LC_BTM_2_INT_PENDING_STS (at 0x3419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_MID_SEL"
      sgroup "VADC2_LC_BTM_2_INT_MID_SEL (at 0x341a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80341a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x341a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC2_LC_BTM_2_INT_PRIORITY"
      sgroup "VADC2_LC_BTM_2_INT_PRIORITY (at 0x341b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80341b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x341b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC2_LC_BTM_2_MODE_CTL"
      sgroup "VADC2_LC_BTM_2_MODE_CTL (at 0x3440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_MULTI_MEAS_EN"
      sgroup "VADC2_LC_BTM_2_MULTI_MEAS_EN (at 0x3441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_MEAS_EN                               = " "0 (M7_MEAS_DISABLE),1 (M7_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_MEAS_EN                               = " "0 (M6_MEAS_DISABLE),1 (M6_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_MEAS_EN                               = " "0 (M5_MEAS_DISABLE),1 (M5_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_MEAS_EN                               = " "0 (M4_MEAS_DISABLE),1 (M4_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_MEAS_EN                               = " "0 (M3_MEAS_DISABLE),1 (M3_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_MEAS_EN                               = " "0 (M2_MEAS_DISABLE),1 (M2_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_MEAS_EN                               = " "0 (M1_MEAS_DISABLE),1 (M1_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_MEAS_EN                               = " "0 (M0_MEAS_DISABLE),1 (M0_MEAS_ENABLE)"
    tree.end
    tree "VADC2_LC_BTM_2_LOW_THR_INT_EN"
      sgroup "VADC2_LC_BTM_2_LOW_THR_INT_EN (at 0x3442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW_THR_INT_EN                        = " "0 (M7_LOW_THR_INT_DISABLED),1 (M7_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW_THR_INT_EN                        = " "0 (M6_LOW_THR_INT_DISABLED),1 (M6_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW_THR_INT_EN                        = " "0 (M5_LOW_THR_INT_DISABLED),1 (M5_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW_THR_INT_EN                        = " "0 (M4_LOW_THR_INT_DISABLED),1 (M4_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW_THR_INT_EN                        = " "0 (M3_LOW_THR_INT_DISABLED),1 (M3_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW_THR_INT_EN                        = " "0 (M2_LOW_THR_INT_DISABLED),1 (M2_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW_THR_INT_EN                        = " "0 (M1_LOW_THR_INT_DISABLED),1 (M1_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW_THR_INT_EN                        = " "0 (M0_LOW_THR_INT_DISABLED),1 (M0_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_HIGH_THR_INT_EN"
      sgroup "VADC2_LC_BTM_2_HIGH_THR_INT_EN (at 0x3443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH_THR_INT_EN                       = " "0 (M7_HIGH_THR_INT_DISABLED),1 (M7_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH_THR_INT_EN                       = " "0 (M6_HIGH_THR_INT_DISABLED),1 (M6_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH_THR_INT_EN                       = " "0 (M5_HIGH_THR_INT_DISABLED),1 (M5_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH_THR_INT_EN                       = " "0 (M4_HIGH_THR_INT_DISABLED),1 (M4_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH_THR_INT_EN                       = " "0 (M3_HIGH_THR_INT_DISABLED),1 (M3_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH_THR_INT_EN                       = " "0 (M2_HIGH_THR_INT_DISABLED),1 (M2_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH_THR_INT_EN                       = " "0 (M1_HIGH_THR_INT_DISABLED),1 (M1_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH_THR_INT_EN                       = " "0 (M0_HIGH_THR_INT_DISABLED),1 (M0_HIGH_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_EN_CTL1"
      sgroup "VADC2_LC_BTM_2_EN_CTL1 (at 0x3446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_M0_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M0_ADC_CH_SEL_CTL (at 0x3448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_ADC_DIG_PARAM"
      sgroup "VADC2_LC_BTM_2_ADC_DIG_PARAM (at 0x3450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC2_LC_BTM_2_HW_SETTLE_DELAY"
      sgroup "VADC2_LC_BTM_2_HW_SETTLE_DELAY (at 0x3451)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC2_LC_BTM_2_CONV_REQ"
      sgroup "VADC2_LC_BTM_2_CONV_REQ (at 0x3452)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_CONV_SEQ_CTL"
      sgroup "VADC2_LC_BTM_2_CONV_SEQ_CTL (at 0x3454)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC2_LC_BTM_2_CONV_SEQ_TRIG_CTL"
      sgroup "VADC2_LC_BTM_2_CONV_SEQ_TRIG_CTL (at 0x3455)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC2_LC_BTM_2_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_MEAS_INTERVAL_CTL (at 0x3457)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME1                      = "
    tree.end
    tree "VADC2_LC_BTM_2_MEAS_INTERVAL_CTL2"
      sgroup "VADC2_LC_BTM_2_MEAS_INTERVAL_CTL2 (at 0x3458)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MEAS_INTERVAL_TIME2                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME3                      = "
    tree.end
    tree "VADC2_LC_BTM_2_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC2_LC_BTM_2_MEAS_INTERVAL_OP_CTL (at 0x3459)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M0_MEAS_INTERVAL_TIME                    = " "0 (M0_USING_TIMER1),1 (M0_USING_TIMER2),2 (M0_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_FAST_AVG_CTL"
      sgroup "VADC2_LC_BTM_2_FAST_AVG_CTL (at 0x345a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC2_LC_BTM_2_FAST_AVG_EN"
      sgroup "VADC2_LC_BTM_2_FAST_AVG_EN (at 0x345b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC2_LC_BTM_2_M0_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M0_LOW_THR0 (at 0x345c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M0_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M0_LOW_THR1 (at 0x345d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M0_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M0_HIGH_THR0 (at 0x345e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M0_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M0_HIGH_THR1 (at 0x345f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80345f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x345f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M0_DATA0"
      sgroup "VADC2_LC_BTM_2_M0_DATA0 (at 0x3460)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M0_DATA1"
      sgroup "VADC2_LC_BTM_2_M0_DATA1 (at 0x3461)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M1_ADC_CH_SEL_CTL (at 0x3468)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M1_LOW_THR0 (at 0x3469)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M1_LOW_THR1 (at 0x346a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80346a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x346a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M1_HIGH_THR0 (at 0x346b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80346b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x346b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M1_HIGH_THR1 (at 0x346c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80346c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x346c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M1_MEAS_INTERVAL_CTL (at 0x346d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80346d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x346d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M1_MEAS_INTERVAL_TIME                    = " "0 (M1_USING_TIMER1),1 (M1_USING_TIMER2),2 (M1_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M2_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M2_ADC_CH_SEL_CTL (at 0x3470)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M2_LOW_THR0 (at 0x3471)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M2_LOW_THR1 (at 0x3472)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M2_HIGH_THR0 (at 0x3473)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M2_HIGH_THR1 (at 0x3474)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M2_MEAS_INTERVAL_CTL (at 0x3475)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M2_MEAS_INTERVAL_TIME                    = " "0 (M2_USING_TIMER1),1 (M2_USING_TIMER2),2 (M2_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M3_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M3_ADC_CH_SEL_CTL (at 0x3478)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M3_LOW_THR0 (at 0x3479)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M3_LOW_THR1 (at 0x347a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80347a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x347a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M3_HIGH_THR0 (at 0x347b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80347b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x347b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M3_HIGH_THR1 (at 0x347c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80347c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x347c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M3_MEAS_INTERVAL_CTL (at 0x347d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80347d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x347d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M3_MEAS_INTERVAL_TIME                    = " "0 (M3_USING_TIMER1),1 (M3_USING_TIMER2),2 (M3_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M4_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M4_ADC_CH_SEL_CTL (at 0x3480)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M4_LOW_THR0 (at 0x3481)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M4_LOW_THR1 (at 0x3482)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M4_HIGH_THR0 (at 0x3483)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M4_HIGH_THR1 (at 0x3484)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M4_MEAS_INTERVAL_CTL (at 0x3485)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M4_MEAS_INTERVAL_TIME                    = " "0 (M4_USING_TIMER1),1 (M4_USING_TIMER2),2 (M4_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M5_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M5_ADC_CH_SEL_CTL (at 0x3488)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M5_LOW_THR0 (at 0x3489)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M5_LOW_THR1 (at 0x348a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80348a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x348a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M5_HIGH_THR0 (at 0x348b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80348b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x348b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M5_HIGH_THR1 (at 0x348c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80348c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x348c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M5_MEAS_INTERVAL_CTL (at 0x348d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80348d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x348d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M5_MEAS_INTERVAL_TIME                    = " "0 (M5_USING_TIMER1),1 (M5_USING_TIMER2),2 (M5_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M6_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M6_ADC_CH_SEL_CTL (at 0x3490)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M6_LOW_THR0 (at 0x3491)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M6_LOW_THR1 (at 0x3492)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M6_HIGH_THR0 (at 0x3493)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M6_HIGH_THR1 (at 0x3494)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M6_MEAS_INTERVAL_CTL (at 0x3495)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M6_MEAS_INTERVAL_TIME                    = " "0 (M6_USING_TIMER1),1 (M6_USING_TIMER2),2 (M6_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M7_ADC_CH_SEL_CTL"
      sgroup "VADC2_LC_BTM_2_M7_ADC_CH_SEL_CTL (at 0x3498)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_LOW_THR0"
      sgroup "VADC2_LC_BTM_2_M7_LOW_THR0 (at 0x3499)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_LOW_THR1"
      sgroup "VADC2_LC_BTM_2_M7_LOW_THR1 (at 0x349a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80349a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x349a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_HIGH_THR0"
      sgroup "VADC2_LC_BTM_2_M7_HIGH_THR0 (at 0x349b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80349b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x349b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_HIGH_THR1"
      sgroup "VADC2_LC_BTM_2_M7_HIGH_THR1 (at 0x349c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80349c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x349c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_MEAS_INTERVAL_CTL"
      sgroup "VADC2_LC_BTM_2_M7_MEAS_INTERVAL_CTL (at 0x349d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x80349d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x349d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M7_MEAS_INTERVAL_TIME                    = " "0 (M7_USING_TIMER1),1 (M7_USING_TIMER2),2 (M7_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_LC_BTM_2_M1_DATA0"
      sgroup "VADC2_LC_BTM_2_M1_DATA0 (at 0x34a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M1_DATA1"
      sgroup "VADC2_LC_BTM_2_M1_DATA1 (at 0x34a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_DATA0"
      sgroup "VADC2_LC_BTM_2_M2_DATA0 (at 0x34a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M2_DATA1"
      sgroup "VADC2_LC_BTM_2_M2_DATA1 (at 0x34a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_DATA0"
      sgroup "VADC2_LC_BTM_2_M3_DATA0 (at 0x34a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M3_DATA1"
      sgroup "VADC2_LC_BTM_2_M3_DATA1 (at 0x34a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_DATA0"
      sgroup "VADC2_LC_BTM_2_M4_DATA0 (at 0x34a6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M4_DATA1"
      sgroup "VADC2_LC_BTM_2_M4_DATA1 (at 0x34a7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_DATA0"
      sgroup "VADC2_LC_BTM_2_M5_DATA0 (at 0x34a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M5_DATA1"
      sgroup "VADC2_LC_BTM_2_M5_DATA1 (at 0x34a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_DATA0"
      sgroup "VADC2_LC_BTM_2_M6_DATA0 (at 0x34aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M6_DATA1"
      sgroup "VADC2_LC_BTM_2_M6_DATA1 (at 0x34ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_DATA0"
      sgroup "VADC2_LC_BTM_2_M7_DATA0 (at 0x34ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_LC_BTM_2_M7_DATA1"
      sgroup "VADC2_LC_BTM_2_M7_DATA1 (at 0x34ad)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_LC_BTM_2_SEC_ACCESS"
      sgroup "VADC2_LC_BTM_2_SEC_ACCESS (at 0x34d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_RESET_CTL1"
      sgroup "VADC2_LC_BTM_2_PERPH_RESET_CTL1 (at 0x34d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_RESET_CTL2"
      sgroup "VADC2_LC_BTM_2_PERPH_RESET_CTL2 (at 0x34d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_RESET_CTL3"
      sgroup "VADC2_LC_BTM_2_PERPH_RESET_CTL3 (at 0x34da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_PERPH_RESET_CTL4"
      sgroup "VADC2_LC_BTM_2_PERPH_RESET_CTL4 (at 0x34db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_TEST1"
      sgroup "VADC2_LC_BTM_2_INT_TEST1 (at 0x34e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_INT_TEST_VAL"
      sgroup "VADC2_LC_BTM_2_INT_TEST_VAL (at 0x34e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC2_LC_BTM_2_TEST1"
      sgroup "VADC2_LC_BTM_2_TEST1 (at 0x34e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        set &access:&cmd_addr %l 0x8034e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x34e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "VADC3_LC_MDM"
  tree "VADC3_LC_MDM"
    tree "VADC3_LC_MDM_REVISION1"
      sgroup "VADC3_LC_MDM_REVISION1 (at 0x3200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_LC_MDM_REVISION2"
      sgroup "VADC3_LC_MDM_REVISION2 (at 0x3201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_LC_MDM_REVISION3"
      sgroup "VADC3_LC_MDM_REVISION3 (at 0x3202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_LC_MDM_REVISION4"
      sgroup "VADC3_LC_MDM_REVISION4 (at 0x3203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_LC_MDM_PERPH_TYPE"
      sgroup "VADC3_LC_MDM_PERPH_TYPE (at 0x3204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_LC_MDM_PERPH_SUBTYPE"
      sgroup "VADC3_LC_MDM_PERPH_SUBTYPE (at 0x3205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_LC_MDM_STATUS1"
      sgroup "VADC3_LC_MDM_STATUS1 (at 0x3208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_LC_MDM_STATUS2"
      sgroup "VADC3_LC_MDM_STATUS2 (at 0x3209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_RT_STS"
      sgroup "VADC3_LC_MDM_INT_RT_STS (at 0x3210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_SET_TYPE"
      sgroup "VADC3_LC_MDM_INT_SET_TYPE (at 0x3211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_LC_MDM_INT_POLARITY_HIGH"
      sgroup "VADC3_LC_MDM_INT_POLARITY_HIGH (at 0x3212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_INT_POLARITY_LOW"
      sgroup "VADC3_LC_MDM_INT_POLARITY_LOW (at 0x3213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_INT_LATCHED_CLR"
      sgroup "VADC3_LC_MDM_INT_LATCHED_CLR (at 0x3214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_LC_MDM_INT_EN_SET"
      sgroup "VADC3_LC_MDM_INT_EN_SET (at 0x3215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_LC_MDM_INT_EN_CLR"
      sgroup "VADC3_LC_MDM_INT_EN_CLR (at 0x3216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_LC_MDM_INT_LATCHED_STS"
      sgroup "VADC3_LC_MDM_INT_LATCHED_STS (at 0x3218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_PENDING_STS"
      sgroup "VADC3_LC_MDM_INT_PENDING_STS (at 0x3219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_MID_SEL"
      sgroup "VADC3_LC_MDM_INT_MID_SEL (at 0x321a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_LC_MDM_INT_PRIORITY"
      sgroup "VADC3_LC_MDM_INT_PRIORITY (at 0x321b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_LC_MDM_MODE_CTL"
      sgroup "VADC3_LC_MDM_MODE_CTL (at 0x3240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_EN_CTL1"
      sgroup "VADC3_LC_MDM_EN_CTL1 (at 0x3246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_ADC_CH_SEL_CTL"
      sgroup "VADC3_LC_MDM_ADC_CH_SEL_CTL (at 0x3248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_LC_MDM_ADC_DIG_PARAM"
      sgroup "VADC3_LC_MDM_ADC_DIG_PARAM (at 0x3250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_LC_MDM_HW_SETTLE_DELAY"
      sgroup "VADC3_LC_MDM_HW_SETTLE_DELAY (at 0x3251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_LC_MDM_CONV_REQ"
      sgroup "VADC3_LC_MDM_CONV_REQ (at 0x3252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_CONV_SEQ_CTL"
      sgroup "VADC3_LC_MDM_CONV_SEQ_CTL (at 0x3254)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_LC_MDM_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_LC_MDM_CONV_SEQ_TRIG_CTL (at 0x3255)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_LC_MDM_MEAS_INTERVAL_CTL"
      sgroup "VADC3_LC_MDM_MEAS_INTERVAL_CTL (at 0x3257)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_LC_MDM_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_LC_MDM_MEAS_INTERVAL_OP_CTL (at 0x3259)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_FAST_AVG_CTL"
      sgroup "VADC3_LC_MDM_FAST_AVG_CTL (at 0x325a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_LC_MDM_FAST_AVG_EN"
      sgroup "VADC3_LC_MDM_FAST_AVG_EN (at 0x325b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_LC_MDM_LOW_THR0"
      sgroup "VADC3_LC_MDM_LOW_THR0 (at 0x325c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_LC_MDM_LOW_THR1"
      sgroup "VADC3_LC_MDM_LOW_THR1 (at 0x325d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_LC_MDM_HIGH_THR0"
      sgroup "VADC3_LC_MDM_HIGH_THR0 (at 0x325e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_LC_MDM_HIGH_THR1"
      sgroup "VADC3_LC_MDM_HIGH_THR1 (at 0x325f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_LC_MDM_DATA0"
      sgroup "VADC3_LC_MDM_DATA0 (at 0x3260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_LC_MDM_DATA1"
      sgroup "VADC3_LC_MDM_DATA1 (at 0x3261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_LC_MDM_MIN_LOW_THR0"
      sgroup "VADC3_LC_MDM_MIN_LOW_THR0 (at 0x3262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_LC_MDM_MIN_LOW_THR1"
      sgroup "VADC3_LC_MDM_MIN_LOW_THR1 (at 0x3263)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_LC_MDM_MIN_DATA0"
      sgroup "VADC3_LC_MDM_MIN_DATA0 (at 0x3266)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_LC_MDM_MIN_DATA1"
      sgroup "VADC3_LC_MDM_MIN_DATA1 (at 0x3267)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_LC_MDM_SEC_ACCESS"
      sgroup "VADC3_LC_MDM_SEC_ACCESS (at 0x32d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_LC_MDM_PERPH_RESET_CTL1"
      sgroup "VADC3_LC_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_LC_MDM_PERPH_RESET_CTL2"
      sgroup "VADC3_LC_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_PERPH_RESET_CTL3"
      sgroup "VADC3_LC_MDM_PERPH_RESET_CTL3 (at 0x32da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_PERPH_RESET_CTL4"
      sgroup "VADC3_LC_MDM_PERPH_RESET_CTL4 (at 0x32db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_TEST1"
      sgroup "VADC3_LC_MDM_INT_TEST1 (at 0x32e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_INT_TEST_VAL"
      sgroup "VADC3_LC_MDM_INT_TEST_VAL (at 0x32e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_LC_MDM_TEST6_DTEST"
      sgroup "VADC3_LC_MDM_TEST6_DTEST (at 0x32e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VADC3_LC_VBMS"
  tree "VADC3_LC_VBMS"
    tree "VADC3_LC_VBMS_REVISION1"
      sgroup "VADC3_LC_VBMS_REVISION1 (at 0x3300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_LC_VBMS_REVISION2"
      sgroup "VADC3_LC_VBMS_REVISION2 (at 0x3301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_LC_VBMS_REVISION3"
      sgroup "VADC3_LC_VBMS_REVISION3 (at 0x3302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_LC_VBMS_REVISION4"
      sgroup "VADC3_LC_VBMS_REVISION4 (at 0x3303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_LC_VBMS_PERPH_TYPE"
      sgroup "VADC3_LC_VBMS_PERPH_TYPE (at 0x3304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_LC_VBMS_PERPH_SUBTYPE"
      sgroup "VADC3_LC_VBMS_PERPH_SUBTYPE (at 0x3305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_LC_VBMS_STATUS1"
      sgroup "VADC3_LC_VBMS_STATUS1 (at 0x3308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_LC_VBMS_STATUS2"
      sgroup "VADC3_LC_VBMS_STATUS2 (at 0x3309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_RT_STS"
      sgroup "VADC3_LC_VBMS_INT_RT_STS (at 0x3310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_SET_TYPE"
      sgroup "VADC3_LC_VBMS_INT_SET_TYPE (at 0x3311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_POLARITY_HIGH"
      sgroup "VADC3_LC_VBMS_INT_POLARITY_HIGH (at 0x3312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_INT_POLARITY_LOW"
      sgroup "VADC3_LC_VBMS_INT_POLARITY_LOW (at 0x3313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_INT_LATCHED_CLR"
      sgroup "VADC3_LC_VBMS_INT_LATCHED_CLR (at 0x3314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_LC_VBMS_INT_EN_SET"
      sgroup "VADC3_LC_VBMS_INT_EN_SET (at 0x3315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_LC_VBMS_INT_EN_CLR"
      sgroup "VADC3_LC_VBMS_INT_EN_CLR (at 0x3316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_LC_VBMS_INT_LATCHED_STS"
      sgroup "VADC3_LC_VBMS_INT_LATCHED_STS (at 0x3318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_PENDING_STS"
      sgroup "VADC3_LC_VBMS_INT_PENDING_STS (at 0x3319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_MID_SEL"
      sgroup "VADC3_LC_VBMS_INT_MID_SEL (at 0x331a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80331a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x331a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_LC_VBMS_INT_PRIORITY"
      sgroup "VADC3_LC_VBMS_INT_PRIORITY (at 0x331b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80331b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x331b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_LC_VBMS_MODE_CTL"
      sgroup "VADC3_LC_VBMS_MODE_CTL (at 0x3340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_EN_CTL1"
      sgroup "VADC3_LC_VBMS_EN_CTL1 (at 0x3346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_ADC_CH_SEL_CTL"
      sgroup "VADC3_LC_VBMS_ADC_CH_SEL_CTL (at 0x3348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_LC_VBMS_ADC_DIG_PARAM"
      sgroup "VADC3_LC_VBMS_ADC_DIG_PARAM (at 0x3350)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_LC_VBMS_HW_SETTLE_DELAY"
      sgroup "VADC3_LC_VBMS_HW_SETTLE_DELAY (at 0x3351)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_LC_VBMS_CONV_REQ"
      sgroup "VADC3_LC_VBMS_CONV_REQ (at 0x3352)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_CONV_SEQ_CTL"
      sgroup "VADC3_LC_VBMS_CONV_SEQ_CTL (at 0x3354)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_LC_VBMS_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_LC_VBMS_CONV_SEQ_TRIG_CTL (at 0x3355)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_LC_VBMS_MEAS_INTERVAL_CTL"
      sgroup "VADC3_LC_VBMS_MEAS_INTERVAL_CTL (at 0x3357)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_LC_VBMS_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_LC_VBMS_MEAS_INTERVAL_OP_CTL (at 0x3359)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_FAST_AVG_CTL"
      sgroup "VADC3_LC_VBMS_FAST_AVG_CTL (at 0x335a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_LC_VBMS_FAST_AVG_EN"
      sgroup "VADC3_LC_VBMS_FAST_AVG_EN (at 0x335b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_LC_VBMS_LOW_THR0"
      sgroup "VADC3_LC_VBMS_LOW_THR0 (at 0x335c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_LC_VBMS_LOW_THR1"
      sgroup "VADC3_LC_VBMS_LOW_THR1 (at 0x335d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_LC_VBMS_HIGH_THR0"
      sgroup "VADC3_LC_VBMS_HIGH_THR0 (at 0x335e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_LC_VBMS_HIGH_THR1"
      sgroup "VADC3_LC_VBMS_HIGH_THR1 (at 0x335f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x80335f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x335f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_LC_VBMS_DATA0"
      sgroup "VADC3_LC_VBMS_DATA0 (at 0x3360)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_LC_VBMS_DATA1"
      sgroup "VADC3_LC_VBMS_DATA1 (at 0x3361)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_LC_VBMS_MIN_LOW_THR0"
      sgroup "VADC3_LC_VBMS_MIN_LOW_THR0 (at 0x3362)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_LC_VBMS_MIN_LOW_THR1"
      sgroup "VADC3_LC_VBMS_MIN_LOW_THR1 (at 0x3363)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_LC_VBMS_MIN_DATA0"
      sgroup "VADC3_LC_VBMS_MIN_DATA0 (at 0x3366)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_LC_VBMS_MIN_DATA1"
      sgroup "VADC3_LC_VBMS_MIN_DATA1 (at 0x3367)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_LC_VBMS_SEC_ACCESS"
      sgroup "VADC3_LC_VBMS_SEC_ACCESS (at 0x33d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_LC_VBMS_PERPH_RESET_CTL1"
      sgroup "VADC3_LC_VBMS_PERPH_RESET_CTL1 (at 0x33d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_LC_VBMS_PERPH_RESET_CTL2"
      sgroup "VADC3_LC_VBMS_PERPH_RESET_CTL2 (at 0x33d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_PERPH_RESET_CTL3"
      sgroup "VADC3_LC_VBMS_PERPH_RESET_CTL3 (at 0x33da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_PERPH_RESET_CTL4"
      sgroup "VADC3_LC_VBMS_PERPH_RESET_CTL4 (at 0x33db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_TEST1"
      sgroup "VADC3_LC_VBMS_INT_TEST1 (at 0x33e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_INT_TEST_VAL"
      sgroup "VADC3_LC_VBMS_INT_TEST_VAL (at 0x33e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_LC_VBMS_TEST6_DTEST"
      sgroup "VADC3_LC_VBMS_TEST6_DTEST (at 0x33e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        set &access:&cmd_addr %l 0x8033e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x33e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VADC4_LC_VBAT"
  tree "VADC4_LC_VBAT"
    tree "VADC4_LC_VBAT_REVISION1"
      sgroup "VADC4_LC_VBAT_REVISION1 (at 0x3500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC4_LC_VBAT_REVISION2"
      sgroup "VADC4_LC_VBAT_REVISION2 (at 0x3501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC4_LC_VBAT_REVISION3"
      sgroup "VADC4_LC_VBAT_REVISION3 (at 0x3502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC4_LC_VBAT_REVISION4"
      sgroup "VADC4_LC_VBAT_REVISION4 (at 0x3503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC4_LC_VBAT_PERPH_TYPE"
      sgroup "VADC4_LC_VBAT_PERPH_TYPE (at 0x3504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC4_LC_VBAT_PERPH_SUBTYPE"
      sgroup "VADC4_LC_VBAT_PERPH_SUBTYPE (at 0x3505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC4_LC_VBAT_STATUS1"
      sgroup "VADC4_LC_VBAT_STATUS1 (at 0x3508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC4_LC_VBAT_STATUS2"
      sgroup "VADC4_LC_VBAT_STATUS2 (at 0x3509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_RT_STS"
      sgroup "VADC4_LC_VBAT_INT_RT_STS (at 0x3510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_SET_TYPE"
      sgroup "VADC4_LC_VBAT_INT_SET_TYPE (at 0x3511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_POLARITY_HIGH"
      sgroup "VADC4_LC_VBAT_INT_POLARITY_HIGH (at 0x3512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_INT_POLARITY_LOW"
      sgroup "VADC4_LC_VBAT_INT_POLARITY_LOW (at 0x3513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_INT_LATCHED_CLR"
      sgroup "VADC4_LC_VBAT_INT_LATCHED_CLR (at 0x3514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC4_LC_VBAT_INT_EN_SET"
      sgroup "VADC4_LC_VBAT_INT_EN_SET (at 0x3515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC4_LC_VBAT_INT_EN_CLR"
      sgroup "VADC4_LC_VBAT_INT_EN_CLR (at 0x3516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC4_LC_VBAT_INT_LATCHED_STS"
      sgroup "VADC4_LC_VBAT_INT_LATCHED_STS (at 0x3518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_PENDING_STS"
      sgroup "VADC4_LC_VBAT_INT_PENDING_STS (at 0x3519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_MID_SEL"
      sgroup "VADC4_LC_VBAT_INT_MID_SEL (at 0x351a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80351a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x351a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC4_LC_VBAT_INT_PRIORITY"
      sgroup "VADC4_LC_VBAT_INT_PRIORITY (at 0x351b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80351b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x351b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC4_LC_VBAT_MODE_CTL"
      sgroup "VADC4_LC_VBAT_MODE_CTL (at 0x3540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_EN_CTL1"
      sgroup "VADC4_LC_VBAT_EN_CTL1 (at 0x3546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_ADC_CH_SEL_CTL"
      sgroup "VADC4_LC_VBAT_ADC_CH_SEL_CTL (at 0x3548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC4_LC_VBAT_ADC_DIG_PARAM"
      sgroup "VADC4_LC_VBAT_ADC_DIG_PARAM (at 0x3550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC4_LC_VBAT_HW_SETTLE_DELAY"
      sgroup "VADC4_LC_VBAT_HW_SETTLE_DELAY (at 0x3551)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC4_LC_VBAT_CONV_REQ"
      sgroup "VADC4_LC_VBAT_CONV_REQ (at 0x3552)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_CONV_SEQ_CTL"
      sgroup "VADC4_LC_VBAT_CONV_SEQ_CTL (at 0x3554)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC4_LC_VBAT_CONV_SEQ_TRIG_CTL"
      sgroup "VADC4_LC_VBAT_CONV_SEQ_TRIG_CTL (at 0x3555)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC4_LC_VBAT_MEAS_INTERVAL_CTL"
      sgroup "VADC4_LC_VBAT_MEAS_INTERVAL_CTL (at 0x3557)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC4_LC_VBAT_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC4_LC_VBAT_MEAS_INTERVAL_OP_CTL (at 0x3559)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_FAST_AVG_CTL"
      sgroup "VADC4_LC_VBAT_FAST_AVG_CTL (at 0x355a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC4_LC_VBAT_FAST_AVG_EN"
      sgroup "VADC4_LC_VBAT_FAST_AVG_EN (at 0x355b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC4_LC_VBAT_LOW_THR0"
      sgroup "VADC4_LC_VBAT_LOW_THR0 (at 0x355c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC4_LC_VBAT_LOW_THR1"
      sgroup "VADC4_LC_VBAT_LOW_THR1 (at 0x355d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC4_LC_VBAT_HIGH_THR0"
      sgroup "VADC4_LC_VBAT_HIGH_THR0 (at 0x355e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC4_LC_VBAT_HIGH_THR1"
      sgroup "VADC4_LC_VBAT_HIGH_THR1 (at 0x355f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x80355f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x355f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC4_LC_VBAT_DATA0"
      sgroup "VADC4_LC_VBAT_DATA0 (at 0x3560)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC4_LC_VBAT_DATA1"
      sgroup "VADC4_LC_VBAT_DATA1 (at 0x3561)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC4_LC_VBAT_MIN_LOW_THR0"
      sgroup "VADC4_LC_VBAT_MIN_LOW_THR0 (at 0x3562)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC4_LC_VBAT_MIN_LOW_THR1"
      sgroup "VADC4_LC_VBAT_MIN_LOW_THR1 (at 0x3563)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC4_LC_VBAT_MIN_DATA0"
      sgroup "VADC4_LC_VBAT_MIN_DATA0 (at 0x3566)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC4_LC_VBAT_MIN_DATA1"
      sgroup "VADC4_LC_VBAT_MIN_DATA1 (at 0x3567)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC4_LC_VBAT_SEC_ACCESS"
      sgroup "VADC4_LC_VBAT_SEC_ACCESS (at 0x35d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC4_LC_VBAT_PERPH_RESET_CTL1"
      sgroup "VADC4_LC_VBAT_PERPH_RESET_CTL1 (at 0x35d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC4_LC_VBAT_PERPH_RESET_CTL2"
      sgroup "VADC4_LC_VBAT_PERPH_RESET_CTL2 (at 0x35d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_PERPH_RESET_CTL3"
      sgroup "VADC4_LC_VBAT_PERPH_RESET_CTL3 (at 0x35da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_PERPH_RESET_CTL4"
      sgroup "VADC4_LC_VBAT_PERPH_RESET_CTL4 (at 0x35db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_TEST1"
      sgroup "VADC4_LC_VBAT_INT_TEST1 (at 0x35e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_INT_TEST_VAL"
      sgroup "VADC4_LC_VBAT_INT_TEST_VAL (at 0x35e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC4_LC_VBAT_TEST6_DTEST"
      sgroup "VADC4_LC_VBAT_TEST6_DTEST (at 0x35e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        set &access:&cmd_addr %l 0x8035e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x35e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VIB1"
  tree "VIB1"
    tree "VIB1_REVISION1"
      sgroup "VIB1_REVISION1 (at 0x1c000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VIB1_REVISION2"
      sgroup "VIB1_REVISION2 (at 0x1c001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VIB1_REVISION3"
      sgroup "VIB1_REVISION3 (at 0x1c002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VIB1_REVISION4"
      sgroup "VIB1_REVISION4 (at 0x1c003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VIB1_PERPH_TYPE"
      sgroup "VIB1_PERPH_TYPE (at 0x1c004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VIB1_PERPH_SUBTYPE"
      sgroup "VIB1_PERPH_SUBTYPE (at 0x1c005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VIB1_STATUS1"
      sgroup "VIB1_STATUS1 (at 0x1c008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VIB_OK                                   = " "0 (VIB_DISABLED),1 (VIB_ENABLED)"
    tree.end
    tree "VIB1_VOLTAGE_CTL2"
      sgroup "VIB1_VOLTAGE_CTL2 (at 0x1c041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   V_SET                                    = "
    tree.end
    tree "VIB1_EN_CTL"
      sgroup "VIB1_EN_CTL (at 0x1c046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (VIB_DISABLED),1 (VIB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   INV_DTEST                                = " "0 (VIB_ENABLE_DTEST_HIGH),1 (VIB_ENABLE_DTEST_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_DTEST3                            = " "0 (VIB_IGNORE_DTEST3),1 (VIB_FOLLOW_DTEST3)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_DTEST2                            = " "0 (VIB_IGNORE_DTEST2),1 (VIB_FOLLOW_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_DTEST1                            = " "0 (VIB_IGNORE_DTEST1),1 (VIB_FOLLOW_DTEST1)"
    tree.end
    tree "VIB1_SEC_ACCESS"
      sgroup "VIB1_SEC_ACCESS (at 0x1c0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VIB1_PERPH_RESET_CTL1"
      sgroup "VIB1_PERPH_RESET_CTL1 (at 0x1c0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "VIB1_PERPH_RESET_CTL2"
      sgroup "VIB1_PERPH_RESET_CTL2 (at 0x1c0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL3"
      sgroup "VIB1_PERPH_RESET_CTL3 (at 0x1c0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL4"
      sgroup "VIB1_PERPH_RESET_CTL4 (at 0x1c0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VIB1_TEST1"
      sgroup "VIB1_TEST1 (at 0x1c0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ILIM_REDUCTION                           = " "0 (VIB_TEST_ILIM_NORMAL),1 (VIB_TEST_ILIM_REDUCED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_VIB_OUT                            = " "0 (VIB_TEST_ATEST1_HI_Z),1 (VIB_TEST_ATEST1_IS_VOUT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST_ISENSE                             = " "0 (VIB_TEST_ATEST2_HI_Z),1 (VIB_TEST_ATEST2_IS_ISENSE)"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      sgroup "VREFLPDDR_REVISION1 (at 0xa00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      sgroup "VREFLPDDR_REVISION2 (at 0xa01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      sgroup "VREFLPDDR_REVISION3 (at 0xa02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      sgroup "VREFLPDDR_REVISION4 (at 0xa03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      sgroup "VREFLPDDR_PERPH_TYPE (at 0xa04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      sgroup "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      sgroup "VREFLPDDR_STATUS1 (at 0xa08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR_OK                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_VREF_LPDDR2_EN"
      sgroup "VREFLPDDR_VREF_LPDDR2_EN (at 0xa44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      sgroup "VREFLPDDR_EN_CTL1 (at 0xa46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      sgroup "VREFLPDDR_SEC_ACCESS (at 0xad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      sgroup "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      sgroup "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      sgroup "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      sgroup "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      sgroup "VREFLPDDR_TRIM_NUM (at 0xaf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL"
      sgroup "VREFLPDDR_TRIM_VAL (at 0xaf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0 (XO19M_OFF),1 (XO19M_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUFF_CORNER                        = " "0 (LOW_CORNER),1 (HIGH_CORNER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO19M_NOT_FORCED),1 (XO19M_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
