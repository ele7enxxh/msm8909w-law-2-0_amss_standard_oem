entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BB_CLK1"
  tree "BB_CLK1"
    tree "BB_CLK1_REVISION1"
      sgroup "BB_CLK1_REVISION1 (at 0x5100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION2"
      sgroup "BB_CLK1_REVISION2 (at 0x5101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK1_REVISION3"
      sgroup "BB_CLK1_REVISION3 (at 0x5102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION4"
      sgroup "BB_CLK1_REVISION4 (at 0x5103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK1_PERPH_TYPE"
      sgroup "BB_CLK1_PERPH_TYPE (at 0x5104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK1_PERPH_SUBTYPE"
      sgroup "BB_CLK1_PERPH_SUBTYPE (at 0x5105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK1_STATUS1"
      sgroup "BB_CLK1_STATUS1 (at 0x5108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK1_EDGE_CTL1"
      sgroup "BB_CLK1_EDGE_CTL1 (at 0x5143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK1_DRV_CTL1"
      sgroup "BB_CLK1_DRV_CTL1 (at 0x5144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK1_EN_CTL"
      sgroup "BB_CLK1_EN_CTL (at 0x5146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK1_PD_CTL"
      sgroup "BB_CLK1_PD_CTL (at 0x5148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK1_SEC_ACCESS"
      sgroup "BB_CLK1_SEC_ACCESS (at 0x51d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL1"
      sgroup "BB_CLK1_PERPH_RESET_CTL1 (at 0x51d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL2"
      sgroup "BB_CLK1_PERPH_RESET_CTL2 (at 0x51d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL3"
      sgroup "BB_CLK1_PERPH_RESET_CTL3 (at 0x51da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL4"
      sgroup "BB_CLK1_PERPH_RESET_CTL4 (at 0x51db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BB_CLK2"
  tree "BB_CLK2"
    tree "BB_CLK2_REVISION1"
      sgroup "BB_CLK2_REVISION1 (at 0x5200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION2"
      sgroup "BB_CLK2_REVISION2 (at 0x5201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK2_REVISION3"
      sgroup "BB_CLK2_REVISION3 (at 0x5202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION4"
      sgroup "BB_CLK2_REVISION4 (at 0x5203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK2_PERPH_TYPE"
      sgroup "BB_CLK2_PERPH_TYPE (at 0x5204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK2_PERPH_SUBTYPE"
      sgroup "BB_CLK2_PERPH_SUBTYPE (at 0x5205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK2_STATUS1"
      sgroup "BB_CLK2_STATUS1 (at 0x5208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK2_EDGE_CTL1"
      sgroup "BB_CLK2_EDGE_CTL1 (at 0x5243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK2_DRV_CTL1"
      sgroup "BB_CLK2_DRV_CTL1 (at 0x5244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK2_EN_CTL"
      sgroup "BB_CLK2_EN_CTL (at 0x5246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK2_PD_CTL"
      sgroup "BB_CLK2_PD_CTL (at 0x5248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK2_SEC_ACCESS"
      sgroup "BB_CLK2_SEC_ACCESS (at 0x52d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL1"
      sgroup "BB_CLK2_PERPH_RESET_CTL1 (at 0x52d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL2"
      sgroup "BB_CLK2_PERPH_RESET_CTL2 (at 0x52d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL3"
      sgroup "BB_CLK2_PERPH_RESET_CTL3 (at 0x52da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL4"
      sgroup "BB_CLK2_PERPH_RESET_CTL4 (at 0x52db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      sgroup "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      sgroup "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      sgroup "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      sgroup "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      sgroup "BCLK_GEN_MAIN_STATUS (at 0x11008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      sgroup "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      sgroup "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      sgroup "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      sgroup "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      sgroup "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      sgroup "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      sgroup "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      sgroup "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      sgroup "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      sgroup "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      sgroup "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      sgroup "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      sgroup "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      sgroup "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      sgroup "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      sgroup "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      sgroup "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BMS_VM"
  tree "BMS_VM"
    tree "BMS_VM_REVISION1"
      sgroup "BMS_VM_REVISION1 (at 0x4000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BMS_VM_REVISION2"
      sgroup "BMS_VM_REVISION2 (at 0x4001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BMS_VM_PERPH_TYPE"
      sgroup "BMS_VM_PERPH_TYPE (at 0x4004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BMS_VM_PERPH_SUBTYPE"
      sgroup "BMS_VM_PERPH_SUBTYPE (at 0x4005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BMS_VM_STATUS1"
      sgroup "BMS_VM_STATUS1 (at 0x4008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_OK                                   = " "0 (BMS_PON_OCV_NOT_DONE),1 (BMS_PON_OCV_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FSM_FORCED                               = " "0 (FSM_NOT_FORCED),1 (FSM_FORCED)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   FSM_STATE                                = " "0 (IDLE),1 (S1),2 (S2),3 (S3),4 (reserved),5 (reserved),6 (reserved),7 (S7)"
    tree.end
    tree "BMS_VM_STATUS2"
      sgroup "BMS_VM_STATUS2 (at 0x4009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   COUNT_OF_RESULTS_IN_FIFO_SD              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   COUNT_OF_RESULTS_IN_FIFO_RT              = "
    tree.end
    tree "BMS_VM_INT_RT_STS"
      sgroup "BMS_VM_INT_RT_STS (at 0x4010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_RT_STS                  = " "0 (FSM_STAT_CHG_INT_RT_STATUS_LOW),1 (FSM_STAT_CHG_INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_RT_STS              = " "0 (FIFO_UPDATE_DONE_INT_RT_STS_LOW),1 (FIFO_UPDATE_DONE_INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_RT_STS                       = " "0 (OCV_THR_INT_RT_STATUS_LOW),1 (OCV_THR_INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_RT_STS                      = " "0 (GOOD_OCV_INT_RT_STATUS_LOW),1 (GOOD_OCV_INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_RT_STS                = " "0 (ENTER_CV_STATE_INT_RT_STATUS_LOW),1 (ENTER_CV_STATE_INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_RT_STS                = " "0 (LEAVE_CV_STATE_INT_RT_STATUS_LOW),1 (LEAVE_CV_STATE_INT_RT_STATUS_HIGH)"
    tree.end
    tree "BMS_VM_INT_SET_TYPE"
      sgroup "BMS_VM_INT_SET_TYPE (at 0x4011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_TYPE                    = " "0 (FSM_STAT_CHG_LEVEL),1 (FSM_STAT_CHG_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_TYPE                = " "0 (FIFO_UPDATE_DONE_LEVEL),1 (FIFO_UPDATE_DONE_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_TYPE                         = " "0 (OCV_THR_LEVEL),1 (OCV_THR_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_TYPE                        = " "0 (GOOD_OCV_LEVEL),1 (GOOD_OCV_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_TYPE                  = " "0 (ENTER_CV_STATE_LEVEL),1 (ENTER_CV_STATE_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_TYPE                  = " "0 (LEAVE_CV_STATE_LEVEL),1 (LEAVE_CV_STATE_EDGE)"
    tree.end
    tree "BMS_VM_INT_POLARITY_HIGH"
      sgroup "BMS_VM_INT_POLARITY_HIGH (at 0x4012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_HIGH                    = " "0 (FSM_STAT_CHG_HIGH_TRIGGER_DISABLED),1 (FSM_STAT_CHG_THR_HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_HIGH                = " "0 (FIFO_UPDATE_DONE_HIGH_TRIGGER_DISABLED),1 (FIFO_UPDATE_DONE_HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_HIGH                         = " "0 (OCV_THR_HIGH_TRIGGER_DISABLED),1 (OCV_THR_HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_HIGH                        = " "0 (GOOD_OCV_HIGH_TRIGGER_DISABLED),1 (GOOD_OCV_HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_HIGH                  = " "0 (ENTER_CV_STATE_HIGH_TRIGGER_DISABLED),1 (ENTER_CV_STATE_HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_HIGH                  = " "0 (LEAVE_CV_STATE_HIGH_TRIGGER_DISABLED),1 (LEAVE_CV_STATE_HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BMS_VM_INT_POLARITY_LOW"
      sgroup "BMS_VM_INT_POLARITY_LOW (at 0x4013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_LOW                     = " "0 (FSM_STAT_CHG_LOW_TRIGGER_DISABLED),1 (FSM_STAT_CHG_LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_LOW                 = " "0 (FIFO_UPDATE_DONE_LOW_TRIGGER_DISABLED),1 (FIFO_UPDATE_DONE_LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_LOW                          = " "0 (OCV_THR_LOW_TRIGGER_DISABLED),1 (OCV_THR_LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_LOW                         = " "0 (GOOD_OCV_LOW_TRIGGER_DISABLED),1 (GOOD_OCV_LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_LOW                   = " "0 (ENTER_CV_STATE_LOW_TRIGGER_DISABLED),1 (ENTER_CV_STATE_LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_LOW                   = " "0 (LEAVE_CV_STATE_LOW_TRIGGER_DISABLED),1 (LEAVE_CV_STATE_LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BMS_VM_INT_LATCHED_CLR"
      sgroup "BMS_VM_INT_LATCHED_CLR (at 0x4014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_CLR                     = " "0 (FSM_STAT_CHG_LATCHED),1 (FSM_STAT_CHG_LATCH_CLEAR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_CLR                 = " "0 (FIFO_UPDATE_DONE_LATCHED),1 (FIFO_UPDATE_DONE_LATCH_CLEAR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_CLR                          = " "0 (OCV_THR_LATCHED),1 (OCV_THR_LATCH_CLEAR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_CLR                         = " "0 (GOOD_OCV_LATCHED),1 (GOOD_OCV_LATCH_CLEAR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_CLR                   = " "0 (ENTER_CV_STATE_LATCHED),1 (ENTER_CV_STATE_LATCH_CLEAR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_CLR                   = " "0 (LEAVE_CV_STATE_LATCHED),1 (LEAVE_CV_STATE_LATCH_CLEAR)"
    tree.end
    tree "BMS_VM_INT_EN_SET"
      sgroup "BMS_VM_INT_EN_SET (at 0x4015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_EN_SET                  = " "0 (FSM_STAT_CHG_INT_DISABLED),1 (FSM_STAT_CHG_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_EN_SET              = " "0 (FIFO_UPDATE_DONE_INT_DISABLED),1 (FIFO_UPDATE_DONE_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_EN_SET                       = " "0 (OCV_THR_INT_DISABLED),1 (OCV_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_EN_SET                      = " "0 (GOOD_OCV_INT_DISABLED),1 (GOOD_OCV_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_EN_SET                = " "0 (ENTER_CV_STATE_INT_DISABLED),1 (ENTER_CV_STATE_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_EN_SET                = " "0 (LEAVE_CV_STATE_INT_DISABLED),1 (LEAVE_CV_STATE_INT_ENABLED)"
    tree.end
    tree "BMS_VM_INT_EN_CLR"
      sgroup "BMS_VM_INT_EN_CLR (at 0x4016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_EN_CLR                  = " "0 (FSM_STAT_CHG_INT_DISABLED),1 (FSM_STAT_CHG_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_EN_CLR              = " "0 (FIFO_UPDATE_DONE_INT_DISABLED),1 (FIFO_UPDATE_DONE_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_EN_CLR                       = " "0 (OCV_THR_INT_DISABLED),1 (OCV_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_EN_CLR                      = " "0 (GOOD_OCV_INT_DISABLED),1 (GOOD_OCV_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_EN_CLR                = " "0 (ENTER_CV_STATE_INT_DISABLED),1 (ENTER_CV_STATE_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_EN_CLR                = " "0 (LEAVE_CV_STATE_INT_DISABLED),1 (LEAVE_CV_STATE_INT_ENABLED)"
    tree.end
    tree "BMS_VM_INT_LATCHED_STS"
      sgroup "BMS_VM_INT_LATCHED_STS (at 0x4018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_LATCHED_STS             = " "0 (FSM_STAT_CHG_NO_INT_LATCHED),1 (FSM_STAT_CHG_INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_LATCHED_STS         = " "0 (FIFO_UPDATE_DONE_NO_INT_LATCHED),1 (FIFO_UPDATE_DONE_INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_LATCHED_STS                  = " "0 (OCV_THR_NO_INT_LATCHED),1 (OCV_THR_INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_LATCHED_STS                 = " "0 (GOOD_OCV_NO_INT_LATCHED),1 (GOOD_OCV_INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_LATCHED_STS           = " "0 (ENTER_CV_STATE_NO_INT_LATCHED),1 (ENTER_CV_STATE_INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_LATCHED_STS           = " "0 (LEAVE_CV_STATE_NO_INT_LATCHED),1 (LEAVE_CV_STATE_INTERRUPT_LATCHED)"
    tree.end
    tree "BMS_VM_INT_PENDING_STS"
      sgroup "BMS_VM_INT_PENDING_STS (at 0x4019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_PENDING_STS             = " "0 (FSM_STAT_CHG_NO_INT_PENDING),1 (FSM_STAT_CHG_INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_PENDING_STS         = " "0 (FIFO_UPDATE_DONE_NO_INT_PENDING),1 (FIFO_UPDATE_DONE_INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_PENDING_STS                  = " "0 (OCV_THR_NO_INT_PENDING),1 (OCV_THR_INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_PENDING_STS                 = " "0 (GOOD_OCV_NO_INT_PENDING),1 (GOOD_OCV_INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_PENDING_STS           = " "0 (ENTER_CV_STATE_NO_INT_PENDING),1 (ENTER_CV_STATE_INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_PENDING_STS           = " "0 (LEAVE_CV_STATE_NO_INT_PENDING),1 (LEAVE_CV_STATE_INTERRUPT_PENDING)"
    tree.end
    tree "BMS_VM_INT_MID_SEL"
      sgroup "BMS_VM_INT_MID_SEL (at 0x401a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BMS_VM_INT_PRIORITY"
      sgroup "BMS_VM_INT_PRIORITY (at 0x401b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "BMS_VM_MODE_CTL"
      sgroup "BMS_VM_MODE_CTL (at 0x4040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BMS_S2_MODE_EN                           = " "0 (BMS_S2_MODE_DISABLED),1 (BMS_S2_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_S2_MODE                            = " "0 (FORCE_S2_MODE_DISABLED),1 (FORCE_S2_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BMS_S3_MODE_EN                           = " "0 (BMS_S3_MODE_DISABLED),1 (BMS_S3_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_S3_MODE                            = " "0 (FORCE_S3_MODE_DISABLED),1 (FORCE_S3_MODE_ENABLED)"
    tree.end
    tree "BMS_VM_DATA_CTL1"
      sgroup "BMS_VM_DATA_CTL1 (at 0x4042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ACCUM_MANUAL_RESET                       = " "0 (ACCUM_RESET_BY_COUNT),1 (ACCUM_ASYNC_RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASTER_HOLD                              = " "0 (MASTER_HOLD_DISABLED),1 (MASTER_HOLD_ENABLED)"
    tree.end
    tree "BMS_VM_DATA_CTL2"
      sgroup "BMS_VM_DATA_CTL2 (at 0x4043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SD_FIFO_CNT_CLR                          = " "0 (reserved),1 (SD_FIFO_CNT_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SD_ACCUM_DATA_CLR                        = " "0 (reserved),1 (SD_ACCUM_DATA_CLR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SD_ACCUM_CNT_CLR                         = " "0 (reserved),1 (SD_ACCUM_CNT_CLR)"
    tree.end
    tree "BMS_VM_S3_OCV_TOL_CTL"
      sgroup "BMS_VM_S3_OCV_TOL_CTL (at 0x4044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   S3_OCV_TOL                               = "
    tree.end
    tree "BMS_VM_EN_CTL"
      sgroup "BMS_VM_EN_CTL (at 0x4046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_EN                                   = " "0 (BMS_DISABLED),1 (BMS_ENABLED)"
    tree.end
    tree "BMS_VM_FIFO_LENGTH_CTL"
      sgroup "BMS_VM_FIFO_LENGTH_CTL (at 0x4047)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   S2_FIFO_LENGTH_SETTING                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_FIFO_LENGTH_SETTING                   = "
    tree.end
    tree "BMS_VM_OCV_THR0"
      sgroup "BMS_VM_OCV_THR0 (at 0x4050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_THR_7_0                              = "
    tree.end
    tree "BMS_VM_OCV_THR1"
      sgroup "BMS_VM_OCV_THR1 (at 0x4051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_THR_15_8                             = "
    tree.end
    tree "BMS_VM_OCV_THR_CTL"
      sgroup "BMS_VM_OCV_THR_CTL (at 0x4053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCV_THR_EN                               = " "0 (OCV_THR_DISABLED),1 (OCV_THR_ENABLED)"
    tree.end
    tree "BMS_VM_S1_SAMPLE_INTERVAL_CTL"
      sgroup "BMS_VM_S1_SAMPLE_INTERVAL_CTL (at 0x4055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SAMPLE_INTERVAL_NORMAL_STATE             = "
    tree.end
    tree "BMS_VM_S2_SAMPLE_INTERVAL_CTL"
      sgroup "BMS_VM_S2_SAMPLE_INTERVAL_CTL (at 0x4056)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SAMPLE_INTERVAL_CV_STATE                 = "
    tree.end
    tree "BMS_VM_S3_SAMPLE_INTERVAL_CTL"
      sgroup "BMS_VM_S3_SAMPLE_INTERVAL_CTL (at 0x4057)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SAMPLE_INTERVAL_OCV_STATE                = "
    tree.end
    tree "BMS_VM_S7_DELAY_INTERVAL_CTL"
      sgroup "BMS_VM_S7_DELAY_INTERVAL_CTL (at 0x4058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMPLE_DELAY_PON_OCV_STATE               = "
    tree.end
    tree "BMS_VM_S1_SAMP_AVG_CTL"
      sgroup "BMS_VM_S1_SAMP_AVG_CTL (at 0x405a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_AVG_NORMAL_STATE                    = "
    tree.end
    tree "BMS_VM_S2_SAMP_AVG_CTL"
      sgroup "BMS_VM_S2_SAMP_AVG_CTL (at 0x405b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_AVG_CV_STATE                        = "
    tree.end
    tree "BMS_VM_S3_SAMP_AVG_CTL"
      sgroup "BMS_VM_S3_SAMP_AVG_CTL (at 0x405c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_AVG_OCV_STATE                       = "
    tree.end
    tree "BMS_VM_S7_SAMP_AVG_CTL"
      sgroup "BMS_VM_S7_SAMP_AVG_CTL (at 0x405d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_AVG_PON_OCV_STATE                   = "
    tree.end
    tree "BMS_VM_S1_ACCUM_CNT_CTL"
      sgroup "BMS_VM_S1_ACCUM_CNT_CTL (at 0x405e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S1_ACCUM_CNT_THR                         = " "0 (S1_ACCUM_CNT_1),1 (S1_ACCUM_CNT_4),2 (S1_ACCUM_CNT_8),3 (S1_ACCUM_CNT_16),4 (S1_ACCUM_CNT_32),5 (S1_ACCUM_CNT_64),6 (S1_ACCUM_CNT_128),7 (S1_ACCUM_CNT_256)"
    tree.end
    tree "BMS_VM_S2_ACCUM_CNT_CTL"
      sgroup "BMS_VM_S2_ACCUM_CNT_CTL (at 0x405f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_ACCUM_CNT_THR                         = " "0 (S2_ACCUM_CNT_1),1 (S2_ACCUM_CNT_4),2 (S2_ACCUM_CNT_8),3 (S2_ACCUM_CNT_16),4 (S2_ACCUM_CNT_32),5 (S2_ACCUM_CNT_64),6 (S2_ACCUM_CNT_128),7 (S2_ACCUM_CNT_256)"
    tree.end
    tree "BMS_VM_ACCUM_DATA0_RT"
      sgroup "BMS_VM_ACCUM_DATA0_RT (at 0x4060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_RT_7_0                        = "
    tree.end
    tree "BMS_VM_ACCUM_DATA1_RT"
      sgroup "BMS_VM_ACCUM_DATA1_RT (at 0x4061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_RT_15_8                       = "
    tree.end
    tree "BMS_VM_ACCUM_DATA2_RT"
      sgroup "BMS_VM_ACCUM_DATA2_RT (at 0x4062)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_RT_23_16                      = "
    tree.end
    tree "BMS_VM_ACCUM_DATA0_SD"
      sgroup "BMS_VM_ACCUM_DATA0_SD (at 0x4063)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_SD_7_0                        = "
    tree.end
    tree "BMS_VM_ACCUM_DATA1_SD"
      sgroup "BMS_VM_ACCUM_DATA1_SD (at 0x4064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_SD_15_8                       = "
    tree.end
    tree "BMS_VM_ACCUM_DATA2_SD"
      sgroup "BMS_VM_ACCUM_DATA2_SD (at 0x4065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_DATA_SD_23_16                      = "
    tree.end
    tree "BMS_VM_ACCUM_CNT_RT"
      sgroup "BMS_VM_ACCUM_CNT_RT (at 0x4066)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_CNT_RT_7_0                         = "
    tree.end
    tree "BMS_VM_ACCUM_CNT_SD"
      sgroup "BMS_VM_ACCUM_CNT_SD (at 0x4067)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUM_CNT_SD_7_0                         = "
    tree.end
    tree "BMS_VM_S3_S7_OCV_DATA0"
      sgroup "BMS_VM_S3_S7_OCV_DATA0 (at 0x406a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   S3_S7_OCV_7_0                            = "
    tree.end
    tree "BMS_VM_S3_S7_OCV_DATA1"
      sgroup "BMS_VM_S3_S7_OCV_DATA1 (at 0x406b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   S3_S7_OCV_15_8                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_0"
      sgroup "BMS_VM_BMS_DATA_REG_0 (at 0x40b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_0                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_1"
      sgroup "BMS_VM_BMS_DATA_REG_1 (at 0x40b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_1                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_2"
      sgroup "BMS_VM_BMS_DATA_REG_2 (at 0x40b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_2                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_3"
      sgroup "BMS_VM_BMS_DATA_REG_3 (at 0x40b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_3                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_4"
      sgroup "BMS_VM_BMS_DATA_REG_4 (at 0x40b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_4                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_5"
      sgroup "BMS_VM_BMS_DATA_REG_5 (at 0x40b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_5                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_6"
      sgroup "BMS_VM_BMS_DATA_REG_6 (at 0x40b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_6                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_7"
      sgroup "BMS_VM_BMS_DATA_REG_7 (at 0x40b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_7                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_8"
      sgroup "BMS_VM_BMS_DATA_REG_8 (at 0x40b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_8                           = "
    tree.end
    tree "BMS_VM_BMS_DATA_REG_9"
      sgroup "BMS_VM_BMS_DATA_REG_9 (at 0x40b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_9                           = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_0_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_0_LSB (at 0x40c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_0_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_0_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_0_MSB (at 0x40c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_0_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_1_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_1_LSB (at 0x40c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_1_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_1_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_1_MSB (at 0x40c3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_1_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_2_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_2_LSB (at 0x40c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_2_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_2_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_2_MSB (at 0x40c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_2_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_3_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_3_LSB (at 0x40c6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_3_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_3_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_3_MSB (at 0x40c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_3_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_4_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_4_LSB (at 0x40c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_4_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_4_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_4_MSB (at 0x40c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_4_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_5_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_5_LSB (at 0x40ca)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ca0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ca0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_5_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_5_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_5_MSB (at 0x40cb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040cb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40cb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_5_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_6_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_6_LSB (at 0x40cc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040cc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40cc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_6_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_6_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_6_MSB (at 0x40cd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040cd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40cd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_6_MSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_7_LSB"
      sgroup "BMS_VM_BMS_FIFO_REG_7_LSB (at 0x40ce)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ce0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ce0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_7_LSB                       = "
    tree.end
    tree "BMS_VM_BMS_FIFO_REG_7_MSB"
      sgroup "BMS_VM_BMS_FIFO_REG_7_MSB (at 0x40cf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040cf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40cf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_FIFO_REG_7_MSB                       = "
    tree.end
    tree "BMS_VM_SEC_ACCESS"
      sgroup "BMS_VM_SEC_ACCESS (at 0x40d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SECURE_ACCESS_CODE                       = "
    tree.end
    tree "BMS_VM_PERPH_RESET_CTL1"
      sgroup "BMS_VM_PERPH_RESET_CTL1 (at 0x40d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BMS_VM_PERPH_RESET_CTL2"
      sgroup "BMS_VM_PERPH_RESET_CTL2 (at 0x40d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BMS_VM_PERPH_RESET_CTL3"
      sgroup "BMS_VM_PERPH_RESET_CTL3 (at 0x40da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BMS_VM_PERPH_RESET_CTL4"
      sgroup "BMS_VM_PERPH_RESET_CTL4 (at 0x40db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BMS_VM_INT_TEST1"
      sgroup "BMS_VM_INT_TEST1 (at 0x40e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BMS_VM_INT_TEST_VAL"
      sgroup "BMS_VM_INT_TEST_VAL (at 0x40e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FSM_STAT_CHG_INT_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_UPDATE_DONE_INT_TEST_VAL            = " "0 (FIFO_UPDATE_DONE_INT_TEST_FALSE),1 (FIFO_UPDATE_DONE_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OCV_THR_INT_TEST_VAL                     = " "0 (OCV_THR_INT_TEST_FALSE),1 (OCV_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_TEST_VAL                    = " "0 (GOOD_OCV_INT_TEST_FALSE),1 (GOOD_OCV_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENTER_CV_STATE_INT_TEST_VAL              = " "0 (ENTER_CV_STATE_INT_TEST_FALSE),1 (ENTER_CV_STATE_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LEAVE_CV_STATE_INT_TEST_VAL              = " "0 (LEAVE_CV_STATE_INT_TEST_FALSE),1 (LEAVE_CV_STATE_INT_TEST_TRUE)"
    tree.end
    tree "BMS_VM_TEST1"
      sgroup "BMS_VM_TEST1 (at 0x40e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUA_4UICC"
  tree "BUA_4UICC"
    tree "BUA_4UICC_REVISION1"
      sgroup "BUA_4UICC_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_4UICC_REVISION2"
      sgroup "BUA_4UICC_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_REVISION3"
      sgroup "BUA_4UICC_REVISION3 (at 0x1c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_4UICC_REVISION4"
      sgroup "BUA_4UICC_REVISION4 (at 0x1c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_PERPH_TYPE"
      sgroup "BUA_4UICC_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_4UICC_PERPH_SUBTYPE"
      sgroup "BUA_4UICC_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_4UICC_STATUS1"
      sgroup "BUA_4UICC_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0, 1"
    tree.end
    tree "BUA_4UICC_STATUS2"
      sgroup "BUA_4UICC_STATUS2 (at 0x1c09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_RT_STS"
      sgroup "BUA_4UICC_INT_RT_STS (at 0x1c10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_SET_TYPE"
      sgroup "BUA_4UICC_INT_SET_TYPE (at 0x1c11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_POLARITY_HIGH"
      sgroup "BUA_4UICC_INT_POLARITY_HIGH (at 0x1c12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_POLARITY_LOW"
      sgroup "BUA_4UICC_INT_POLARITY_LOW (at 0x1c13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_LATCHED_CLR"
      sgroup "BUA_4UICC_INT_LATCHED_CLR (at 0x1c14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_EN_SET"
      sgroup "BUA_4UICC_INT_EN_SET (at 0x1c15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_EN_CLR"
      sgroup "BUA_4UICC_INT_EN_CLR (at 0x1c16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_LATCHED_STS"
      sgroup "BUA_4UICC_INT_LATCHED_STS (at 0x1c18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_PENDING_STS"
      sgroup "BUA_4UICC_INT_PENDING_STS (at 0x1c19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_MID_SEL"
      sgroup "BUA_4UICC_INT_MID_SEL (at 0x1c1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BUA_4UICC_INT_PRIORITY"
      sgroup "BUA_4UICC_INT_PRIORITY (at 0x1c1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BUA_4UICC_BUA_CTL1"
      sgroup "BUA_4UICC_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUA_4UICC_EN_CTL1"
      sgroup "BUA_4UICC_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_SEC_ACCESS"
      sgroup "BUA_4UICC_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_4UICC_PERPH_RESET_CTL1"
      sgroup "BUA_4UICC_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BUA_4UICC_PERPH_RESET_CTL2"
      sgroup "BUA_4UICC_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_PERPH_RESET_CTL3"
      sgroup "BUA_4UICC_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_PERPH_RESET_CTL4"
      sgroup "BUA_4UICC_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_TEST1"
      sgroup "BUA_4UICC_INT_TEST1 (at 0x1ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_INT_TEST_VAL"
      sgroup "BUA_4UICC_INT_TEST_VAL (at 0x1ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_TEST1"
      sgroup "BUA_4UICC_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST_SEL2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CDC_A"
  tree "CDC_A"
    tree "CDC_A_REVISION1"
      sgroup "CDC_A_REVISION1 (at 0x1f100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CDC_A_REVISION2"
      sgroup "CDC_A_REVISION2 (at 0x1f101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CDC_A_REVISION3"
      sgroup "CDC_A_REVISION3 (at 0x1f102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CDC_A_REVISION4"
      sgroup "CDC_A_REVISION4 (at 0x1f103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CDC_A_PERPH_TYPE"
      sgroup "CDC_A_PERPH_TYPE (at 0x1f104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CDC_A_PERPH_SUBTYPE"
      sgroup "CDC_A_PERPH_SUBTYPE (at 0x1f105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CDC_A_INT_RT_STS"
      sgroup "CDC_A_INT_RT_STS (at 0x1f110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_SET_TYPE"
      sgroup "CDC_A_INT_SET_TYPE (at 0x1f111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_POLARITY_HIGH"
      sgroup "CDC_A_INT_POLARITY_HIGH (at 0x1f112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_POLARITY_LOW"
      sgroup "CDC_A_INT_POLARITY_LOW (at 0x1f113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_LATCHED_CLR"
      sgroup "CDC_A_INT_LATCHED_CLR (at 0x1f114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_EN_SET"
      sgroup "CDC_A_INT_EN_SET (at 0x1f115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_EN_CLR"
      sgroup "CDC_A_INT_EN_CLR (at 0x1f116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_LATCHED_STS"
      sgroup "CDC_A_INT_LATCHED_STS (at 0x1f118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_PENDING_STS"
      sgroup "CDC_A_INT_PENDING_STS (at 0x1f119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_INT_MID_SEL"
      sgroup "CDC_A_INT_MID_SEL (at 0x1f11a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "CDC_A_INT_PRIORITY"
      sgroup "CDC_A_INT_PRIORITY (at 0x1f11b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "CDC_A_MICB_1_EN"
      sgroup "CDC_A_MICB_1_EN (at 0x1f140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MICB_EN                                  = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAP_MODE                                 = " "0 (EXT_BYP_CAP),1 (NO_EXT_BYP_CAP)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PULL_DOWN_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PULL_UP_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   OPA_STG3_TAIL_CURR                       = " "0 (I_30_UA),1 (I_45_UA),2 (I_60_UA),3 (I_75_UA),4 (I_90_UA),5 (I_105_UA),6 (I_120_UA),7 (I_135_UA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX3N_GND_SEL                             = " "0 (TX_GND),1 (HPH_REF)"
    tree.end
    tree "CDC_A_MICB_1_VAL"
      sgroup "CDC_A_MICB_1_VAL (at 0x1f141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   MICB_OUT_VAL                             = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   IFILT_RES_VAL                            = " "0 (R_3600M_OHM),1 (R_1800M_OHM),2 (R_1200M_OHM),3 (R_900M_OHM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MICB_PWR_SWCH_OVRD_EN                    = " "0 (AUTO),1 (VDD_MIC_BIAS)"
    tree.end
    tree "CDC_A_MICB_1_CTL"
      sgroup "CDC_A_MICB_1_CTL (at 0x1f142)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_OPA_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   INT_PRECHRG_BYP                          = " "0 (INT_PRECHRG_SEL),1 (EXT_PRECHRG_SEL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EXT_PRECHRG_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   ATEST_CTL                                = " "0 (DISABLE),1 (VHIGH_VREF_SEL),2 (NBIAS_NCASC_SEL),3 (PBIAS_PCASC_SEL),4 (IREF_SQRT_2P5U_IREF2_SQRT_2P5U_SEL),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFILT_REF_SEL                            = " "0 (CDC_GND_CFILT),1 (HPH_REF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PLUG_PNP_OVRD                            = " "0 (ENABLE),1 (DISABLE)"
    tree.end
    tree "CDC_A_MICB_1_INT_RBIAS"
      sgroup "CDC_A_MICB_1_INT_RBIAS (at 0x1f143)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TX1_INT_RBIAS_EN                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TX1N_INT_PULLUP_EN                       = " "0 (TX1N_TO_GND),1 (TX1N_TO_MBIAS)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TX1N_GND_SEL                             = " "0 (TX_GND),1 (HPH_REF)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TX2_INT_RBIAS_EN                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX2N_INT_PULLUP_EN                       = " "0 (TX2N_TO_GND),1 (TX2N_TO_MBIAS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TX2N_GND_SEL                             = " "0 (TX_GND),1 (HPH_REF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TX3_INT_RBIAS_EN                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX3_INT_PULLUP_EN                        = " "0 (TX2N_TO_GND),1 (TX2N_TO_MBIAS)"
    tree.end
    tree "CDC_A_MICB_2_EN"
      sgroup "CDC_A_MICB_2_EN (at 0x1f144)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MICB_EN                                  = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PULL_UP_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PULL_DOWN_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MBHC_AZ_CTL                              = " "0 (DEFAULT_AZ_EQ_MICB_EN_B),1 (DISABLE_AZ),2 (ENABLE_AZ),3 (reserved)"
    tree.end
    tree "CDC_A_TX_1_2_ATEST_CTL_2"
      sgroup "CDC_A_TX_1_2_ATEST_CTL_2 (at 0x1f145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   TXFE1_ATEST_CTL                          = " "0 (DISABLE),1 (OUTP_OUTM),2 (VCMI_VCMO),3 (NWELL_VDDATEST),4 (VDDH_VDDL),5 (VDDHI1_VDDLI1),6 (VDDHI2_VDDLI2),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   TXFE2_ATEST_CTL                          = " "0 (DISABLE),1 (OUTP_OUTM),2 (VCMI_VCMO),3 (NWELL_VDDATEST),4 (VDDH_VDDL),5 (VDDHI1_VDDLI1),6 (VDDHI2_VDDLI2),7 (reserved)"
    tree.end
    tree "CDC_A_MASTER_BIAS_CTL"
      sgroup "CDC_A_MASTER_BIAS_CTL (at 0x1f146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASTER_BIAS_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   V2I_BUFFER_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST_TRIM_CTL                           = " "0 (TRIM_TO_CODEC),1 (TRIM_TO_ATEST),2 (ATEST_TO_CODEC),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_RPOLY_CTL                          = " "0 (RPOLY_TO_CODEC),1 (RPOLY_TO_ATEST)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FREEZE_EN                                = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_MBHC_DET_CTL_1"
      sgroup "CDC_A_MBHC_DET_CTL_1 (at 0x1f147)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   L_DET_EN                                 = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GND_DET_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MECH_DETECTION_TYPE                      = " "0 (REMOVAL),1 (INSERTION)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MIC_CLAMP_CTL                            = " "0 (MANUAL_CONTROL_CLAMP_OFF),1 (MANUAL_CONTROL_CLAMP_ON),2 (AUTOMATIC_CONTROL_CLAMP_MIC),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MBHC_BIAS_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZDET_LEGACY_EN                           = " "0 (RAMP),1 (LEGACY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ELECT_DETECTION_TYPE                     = " "0 (REMOVAL),1 (INSERTION)"
    tree.end
    tree "CDC_A_MBHC_DET_CTL_2"
      sgroup "CDC_A_MBHC_DET_CTL_2 (at 0x1f150)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   HS_L_DET_PULL_UP_CTRL                    = " "0 (OFF),1 (I_IP0_UA),2 (I_2P0_UA),3 (I_3P0_UA)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HS_L_DET_COMPARATOR_CTRL                 = " "0 (OFF),1 (V_0P9_VDD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HPHL_PLUG_TYPE                           = " "0 (NO),1 (NC)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GND_PLUG_TYPE                            = " "0 (NO),1 (NC)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   ELECT_SCHMT_ISRC_CTRL                    = " "0 (DISABLE_ALL),1 (ENABLE_MIC_HPHL_HPHR),2 (ENABLE_HPHL_HPHR),3 (ENABLE_MIC_HPHL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_HPH_LP_100K_TO_GND                    = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_MBHC_FSM_CTL"
      sgroup "CDC_A_MBHC_FSM_CTL (at 0x1f151)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_FSM_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BTN_ISRC_CTRL                            = " "0 (OFF),1 (I_50_UA),2 (I_75_UA),3 (I_100_UA),4 (I_125_UA),5 (I_150_UA),6 (I_175_UA),7 (I_200_UA)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ZDET_L_MEAS_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ZDET_R_MEAS_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZDET_CHG                                 = " "0 (DISCHG),1 (CHG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZDET_DISCHG_CAP_CTL                      = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_MBHC_DBNC_TIMER"
      sgroup "CDC_A_MBHC_DBNC_TIMER (at 0x1f152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   INSREM_DBNC                              = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BTN_DBNC                                 = " "0 (T_0_MS),1 (T_8_MS),2 (T_16_MS),3 (T_32_MS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBHC_ATEST                               = " "0 (reserved),1 (COMP_OUT),2 (VREF_COMP),3 (VIN_COMP)"
    tree.end
    tree "CDC_A_MBHC_BTN_ZDET_CTL_0"
      sgroup "CDC_A_MBHC_BTN_ZDET_CTL_0 (at 0x1f153)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BTN0_VREF_COARSE                         = " "0 (V_0_MV),1 (V_100_MV),2 (V_200_MV),3 (V_300_MV),4 (V_400_MV),5 (V_500_MV),6 (V_600_MV),7 (V_700_MV)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BTN0_VREF_FINE                           = " "0 (V_0P0_MV),1 (V_12P5_MV),2 (V_25P0_MV),3 (V_37P5_MV),4 (V_50P0_MV),5 (V_62P5_MV),6 (V_75P0_MV),7 (V_87P5_MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZDET_CONN_RAMP_L                         = " "0 (DISCONNECT),1 (CONNECT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZDET_CONN_RAMP_R                         = " "0 (DISCONNECT),1 (CONNECT)"
    tree.end
    tree "CDC_A_MBHC_BTN_ZDET_CTL_1"
      sgroup "CDC_A_MBHC_BTN_ZDET_CTL_1 (at 0x1f154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BTN1_VREF_COARSE                         = " "0 (V_0_MV),1 (V_100_MV),2 (V_200_MV),3 (V_300_MV),4 (V_400_MV),5 (V_500_MV),6 (V_600_MV),7 (V_700_MV)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BTN1_VREF_FINE                           = " "0 (V_0P0_MV),1 (V_12P5_MV),2 (V_25P0_MV),3 (V_37P5_MV),4 (V_50P0_MV),5 (V_62P5_MV),6 (V_75P0_MV),7 (V_87P5_MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZDET_CONN_FIXED_L                        = " "0 (DISCONNECT),1 (CONNECT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZDET_CONN_FIXED_R                        = " "0 (DISCONNECT),1 (CONNECT)"
    tree.end
    tree "CDC_A_MBHC_BTN_ZDET_CTL_2"
      sgroup "CDC_A_MBHC_BTN_ZDET_CTL_2 (at 0x1f155)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BTN2_VREF_COARSE                         = " "0 (V_0_MV),1 (V_100_MV),2 (V_200_MV),3 (V_300_MV),4 (V_400_MV),5 (V_500_MV),6 (V_600_MV),7 (V_700_MV)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BTN2_VREF_FINE                           = " "0 (V_0P0_MV),1 (V_12P5_MV),2 (V_25P0_MV),3 (V_37P5_MV),4 (V_50P0_MV),5 (V_62P5_MV),6 (V_75P0_MV),7 (V_87P5_MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZDET_RAMP_CAP_CTL                        = " "0 (NO_CAP),1 (CAP_1F),2 (CAP_2F),3 (CAP_4F)"
    tree.end
    tree "CDC_A_MBHC_BTN3_CTL"
      sgroup "CDC_A_MBHC_BTN3_CTL (at 0x1f156)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BTN3_VREF_COARSE                         = " "0 (V_0_MV),1 (V_100_MV),2 (V_200_MV),3 (V_300_MV),4 (V_400_MV),5 (V_500_MV),6 (V_600_MV),7 (V_700_MV)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BTN3_VREF_FINE                           = " "0 (V_0P0_MV),1 (V_12P5_MV),2 (V_25P0_MV),3 (V_37P5_MV),4 (V_50P0_MV),5 (V_62P5_MV),6 (V_75P0_MV),7 (V_87P5_MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HS_VREF                                  = " "0 (V_1P4_V),1 (V_1P5_V),2 (V_1P6_V),3 (V_1P7_V)"
    tree.end
    tree "CDC_A_MBHC_BTN4_CTL"
      sgroup "CDC_A_MBHC_BTN4_CTL (at 0x1f157)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BTN4_VREF_COARSE                         = " "0 (V_0_MV),1 (V_100_MV),2 (V_200_MV),3 (V_300_MV),4 (V_400_MV),5 (V_500_MV),6 (V_600_MV),7 (V_700_MV)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BTN4_VREF_FINE                           = " "0 (V_0P0_MV),1 (V_12P5_MV),2 (V_25P0_MV),3 (V_37P5_MV),4 (V_50P0_MV),5 (V_62P5_MV),6 (V_75P0_MV),7 (V_87P5_MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FSM_DEBUG                                = " "0 (STATE_0),1 (STATE_1),2 (STATE_2),3 (STATE_3)"
    tree.end
    tree "CDC_A_MBHC_RESULT_1"
      sgroup "CDC_A_MBHC_RESULT_1 (at 0x1f158)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ZDETB5_RESULT                            = " "0 (COMP_LOW),1 (COMP_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BTN4_ZDETB4_RESULT                       = " "0 (COMP_LOW),1 (COMP_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BTN3_ZDETB3_RESULT                       = " "0 (COMP_LOW),1 (COMP_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BTN2_ZDETB2_RESULT                       = " "0 (COMP_LOW),1 (COMP_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BTN1_ZDETB1_RESULT                       = " "0 (COMP_LOW),1 (COMP_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BTN0_ZDETB0_RESULT                       = " "0 (COMP_LOW),1 (COMP_HIGH)"
    tree.end
    tree "CDC_A_MBHC_RESULT_2"
      sgroup "CDC_A_MBHC_RESULT_2 (at 0x1f159)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ZDETL_RESULT                             = " "0 (BELOW_L_TH),1 (BTWN_L_M_TH),2 (BTWN_M_H_TH),3 (ABOVE_H_TH)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZDETR_RESULT                             = " "0 (BELOW_L_TH),1 (BTWN_L_M_TH),2 (BTWN_M_H_TH),3 (ABOVE_H_TH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HPHL_SCHMT_RESULT_2                      = " "0 (INSERTED),1 (REMOVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HPHL_SCHMT_RESULT_1                      = " "0 (INSERTED),1 (REMOVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIC_SCHMT_RESULT                         = " "0 (INSERTED),1 (REMOVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HS_COMP_RESULT                           = " "0 (COMP_LOW),1 (COMP_HIGH)"
    tree.end
    tree "CDC_A_TX_1_EN"
      sgroup "CDC_A_TX_1_EN (at 0x1f160)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CH1_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   CH1_GAIN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TXFE1_AAF2_CURR_CTL                      = " "0 (I_1_NA),1 (I_6_NA),2 (I_11_NA),3 (I_16_NA),4 (I_21_NA),5 (I_26_NA),6 (I_31_NA),7 (I_36_NA)"
    tree.end
    tree "CDC_A_TX_2_EN"
      sgroup "CDC_A_TX_2_EN (at 0x1f161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CH2_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   CH2_GAIN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TXFE2_AAF2_CURR_CTL                      = " "0 (I_1_NA),1 (I_6_NA),2 (I_11_NA),3 (I_16_NA),4 (I_21_NA),5 (I_26_NA),6 (I_31_NA),7 (I_36_NA)"
    tree.end
    tree "CDC_A_TX_1_2_TEST_CTL_1"
      sgroup "CDC_A_TX_1_2_TEST_CTL_1 (at 0x1f162)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TXFE_EN                                  = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TXFE_BYPASS_MODE_EN                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_INT1_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_INT2_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_FLASH_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REF_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CMGEN_EN                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_TX_1_2_TEST_CTL_2"
      sgroup "CDC_A_TX_1_2_TEST_CTL_2 (at 0x1f163)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_CLKGEN_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TXFE_CLKDIV_RESET                        = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TXFE1_INIT_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TXFE2_INIT_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DAC_DEM_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_DITHER_EN                            = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_TX_1_2_ATEST_CTL"
      sgroup "CDC_A_TX_1_2_ATEST_CTL (at 0x1f164)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST_EN                                 = "
    tree.end
    tree "CDC_A_TX_1_2_OPAMP_BIAS"
      sgroup "CDC_A_TX_1_2_OPAMP_BIAS (at 0x1f165)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ADC_INT1_OPAMP_BIAS                      = " "0 (I_2_UA),1 (I_3_UA),2 (I_4_UA),3 (I_5_UA),4 (I_6_UA),5 (I_7_UA),6 (I_8_UA),7 (I_9_UA)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ADC_INT2_OPAMP_BIAS                      = " "0 (I_0P5_UA),1 (I_1_UA),2 (I_1P5_UA),3 (I_2_UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_REF_BIAS                             = " "0 (I_1_UA),1 (I_1P5_UA),2 (I_2_UA),3 (I_2P5_UA),4 (I_3_UA),5 (I_3P5_UA),6 (I_4_UA),7 (I_4P5_UA)"
    tree.end
    tree "CDC_A_TX_1_2_TXFE_CLKDIV"
      sgroup "CDC_A_TX_1_2_TXFE_CLKDIV (at 0x1f166)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   TXFE_1_2_CLK_DIV_RATIO_A1                = " "0 (DIV_BY_1),1 (DIV_BY_2),2 (DIV_BY_4),3 (DIV_BY_8),4 (DIV_BY_16),5 (DIV_BY_32),6 (DIV_BY_64),7 (DIV_BY_128)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TXFE_1_2_CLK_DIV_RATIO_A2                = " "0 (DIV_BY_1),1 (DIV_BY_25)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   TXFE_1_2_CLK_DIV_RATIO_B1                = " "0 (DIV_BY_1),1 (DIV_BY_2),2 (DIV_BY_4),3 (DIV_BY_8),4 (DIV_BY_16),5 (DIV_BY_32),6 (DIV_BY_64),7 (DIV_BY_128)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TXFE_1_2_CLK_DIV_RATIO_B2                = " "0 (DIV_BY_1),1 (DIV_BY_25)"
    tree.end
    tree "CDC_A_TX_3_EN"
      sgroup "CDC_A_TX_3_EN (at 0x1f167)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CH3_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   CH3_GAIN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TXFE_1_2_OPAMP_CURR_CTL                  = " "0 (I_1P5_UA),1 (I_2P0_UA),2 (I_2P5_UA),3 (I_3P0_UA),4 (I_3P5_UA),5 (I_4P0_UA),6 (I_4P5_UA),7 (I_5P0_UA)"
    tree.end
    tree "CDC_A_NCP_EN"
      sgroup "CDC_A_NCP_EN (at 0x1f180)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   NCP_CLIM_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NCP_BYPASS                               = " "0 (NO_BYPASS_NCP),1 (BYPASS_NCP_GND)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FB_BYPASS                                = " "0 (ENABLE_FB_LOOP),1 (BYPASS_FB_LOOP)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CURR_STARVE_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GLITCH_SUP_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NCP_EN                                   = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_NCP_CLK"
      sgroup "CDC_A_NCP_CLK (at 0x1f181)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_SEL                                  = " "0 (PMIC_DEBUG_CLK),1 (CODEC_MCLK)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CLK_INV                                  = " "0 (NON_INV_CLK),1 (INVERTED_CLK)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "CDC_A_NCP_DEGLITCH"
      sgroup "CDC_A_NCP_DEGLITCH (at 0x1f182)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IB_DG_CTRL                               = " "0 (I_1_UA),1 (I_2_UA),2 (I_3_UA),3 (I_4_UA)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NON_TOVP_OUT                             = " "0 (NON_OVP_TIME_7_NS),1 (NON_OVP_TIME_12_NS),2 (NON_OVP_TIME_17P5_NS),3 (NON_OVP_TIME_22P8_NS),4 (NON_OVP_TIME_28P9_NS),5 (NON_OVP_TIME_34P6_NS),6 (NON_OVP_TIME_40P8_NS),7 (NON_OVP_TIME_46P8_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NON_TOVP_IN                              = " "0 (NON_OVP_TIME_7_NS),1 (NON_OVP_TIME_12_NS),2 (NON_OVP_TIME_17P5_NS),3 (NON_OVP_TIME_22P8_NS),4 (NON_OVP_TIME_28P9_NS),5 (NON_OVP_TIME_34P6_NS),6 (NON_OVP_TIME_40P8_NS),7 (NON_OVP_TIME_46P8_NS)"
    tree.end
    tree "CDC_A_NCP_FBCTRL"
      sgroup "CDC_A_NCP_FBCTRL (at 0x1f183)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FB_EN_SWCLK                              = " "0 (CONTROLS_SWTICHING_CLK),1 (NOT_CONTROL_SWITCHING_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FB_CLK_INV                               = " "0 (NON_INVERTED_CLK),1 (INVERTED_CLK)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_BYP                               = " "0 (SAMPLE_WITH_CLK),1 (WITHOUT_SAMPLER)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SAMPLE_SWCLK_BYP                         = " "0 (CLOCK_DIVIDER_OR_MCLK),1 (SWITCHING_CLOCK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_MCLK_BYP                          = " "0 (CLOCK_DIVIDER),1 (MCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SAMPLE_FREQ_DIV                          = " "0 (DIV_FREQ_0P5),1 (DIV_FREQ_2),2 (DIV_FREQ_4),3 (DIV_FREQ_8)"
    tree.end
    tree "CDC_A_NCP_BIAS"
      sgroup "CDC_A_NCP_BIAS (at 0x1f184)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   IB_LDO_1UA                               = " "0 (I_0P5_UA),1 (I_1_UA),2 (I_1P5_UA),3 (I_2_UA),4 (I_2P5_UA),5 (I_3_UA),6 (I_3P5_UA),7 (I_4_UA)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   IB_DG_CTRL2                              = " "0 (I_5_UA),1 (I_10_UA),2 (I_15_UA),3 (I_20_UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IB_COMP1_5UA                             = " "0 (I_2P5_UA),1 (I_5_UA),2 (I_7P5_UA),3 (I_10_UA),4 (I_12P5_UA),5 (I_15_UA),6 (I_17P5_UA),7 (I_20_UA)"
    tree.end
    tree "CDC_A_NCP_VCTRL"
      sgroup "CDC_A_NCP_VCTRL (at 0x1f185)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LDO_VCTRLB                               = " "0 (VDR_2P2V),1 (VDR_2P4V),2 (VDR_2P6V),3 (VDR_2P8V),4 (VDR_3V),5 (VDR_3P2V),6 (VDR_3P4V),7 (VDR_3P6V)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VNEG_OUT                                 = " "0 (VNEG_1P1V),1 (VNEG_1P2V),2 (VNEG_1P3V),3 (VNEG_1P4V),4 (VNEG_1P5V),5 (VNEG_1P6V),6 (VNEG_1P7V),7 (VNEG_1P8V)"
    tree.end
    tree "CDC_A_NCP_TEST"
      sgroup "CDC_A_NCP_TEST (at 0x1f186)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   NCP_ATEST                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NCP_DTEST                                = "
    tree.end
    tree "CDC_A_NCP_CLIM"
      sgroup "CDC_A_NCP_CLIM (at 0x1f187)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   IN_SW_2_DELAY                            = " "0 (SW_2_DELAY_CLK_DIV_2),1 (SW_2_DELAY_CLK_DIV_4),2 (SW_2_DELAY_CLK_DIV_8),3 (SW_2_DELAY_CLK_DIV_16),4 (SW_2_DELAY_CLK_DIV_32),5 (SW_2_DELAY_CLK_DIV_64),6 (SW_2_DELAY_CLK_DIV_128),7 (SW_2_DELAY_CLK_DIV_256)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   IN_SW_1_DELAY                            = " "0 (SW_1_DELAY_CLK_DIV_32),1 (SW_1_DELAY_CLK_DIV_64),2 (SW_1_DELAY_CLK_DIV_128),3 (SW_1_DELAY_CLK_DIV_256)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IN_SW_0_DELAY                            = " "0 (SW_0_DELAY_CLK_DIV_2),1 (SW_0_DELAY_CLK_DIV_4),2 (SW_0_DELAY_CLK_DIV_8),3 (SW_0_DELAY_CLK_DIV_16),4 (SW_0_DELAY_CLK_DIV_32),5 (SW_0_DELAY_CLK_DIV_64),6 (SW_0_DELAY_CLK_DIV_128),7 (SW_0_DELAY_CLK_DIV_256)"
    tree.end
    tree "CDC_A_RX_CLOCK_DIVIDER"
      sgroup "CDC_A_RX_CLOCK_DIVIDER (at 0x1f190)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x7 1 "  [ 7: 1]   RX_CLK_DIVIDER                           = "
    tree.end
    tree "CDC_A_RX_COM_OCP_CTL"
      sgroup "CDC_A_RX_COM_OCP_CTL (at 0x1f191)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   OCP_CURR_LIMIT                           = " "0 (I_280MA),1 (reserved),2 (I_370MA),3 (I_440MA),4 (I_140MA),5 (reserved),6 (I_185MA),7 (I_220MA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCP_FSM_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   N_CONN_ATTEMPTS                          = "
    tree.end
    tree "CDC_A_RX_COM_OCP_COUNT"
      sgroup "CDC_A_RX_COM_OCP_COUNT (at 0x1f192)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RUN_N_CYCLES                             = " "0 (N_511),1 (reserved),2 (reserved),3 (N_2047),4 (reserved),5 (reserved),6 (reserved),7 (N_4095)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   WAIT_N_CYCLES                            = " "0 (N_511),1 (reserved),2 (reserved),3 (N_2047),4 (reserved),5 (reserved),6 (reserved),7 (N_4095)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_LOCK_EN                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_COM_BIAS_DAC"
      sgroup "CDC_A_RX_COM_BIAS_DAC (at 0x1f193)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RX_BIAS_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_BIAS_CURR                           = " "0 (I_0UA),1 (I_1UA),2 (I_2UA),3 (I_3UA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DAC_CLK_SEL                              = " "0 (ANALOG),1 (DIGITAL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DAC_GAIN                                 = " "0 (G_0DB),1 (G_0P27DB),2 (G_0P54DB),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DAC_REF_EN                               = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_HPH_BIAS_PA"
      sgroup "CDC_A_RX_HPH_BIAS_PA (at 0x1f194)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DAC_BIAS_CURR                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PA_BIAS_CURR                             = "
    tree.end
    tree "CDC_A_RX_HPH_BIAS_LDO_OCP"
      sgroup "CDC_A_RX_HPH_BIAS_LDO_OCP (at 0x1f195)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LDO_OTA_BIAS_CURR                        = " "0 (I_1P5UA),1 (I_2P0UA),2 (I_2P5UA),3 (I_3P0UA)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LDO_OUT_BIAS_CURR                        = " "0 (I_3P0UA),1 (I_3P5UA),2 (I_4P0UA),3 (I_4P5UA)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OCP_REF_CURR                             = " "0 (I_4P0UA),1 (I_4P5UA),2 (I_5P0UA),3 (I_5P5UA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SPK_DAC_BIAS_CURR                        = " "0 (I_2P0UA),1 (I_2P5UA),2 (I_3P0UA),3 (I_3P5UA)"
    tree.end
    tree "CDC_A_RX_HPH_BIAS_CNP"
      sgroup "CDC_A_RX_HPH_BIAS_CNP (at 0x1f196)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WG_CURR                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OTA_BIAS_CURR                            = " "0 (I_3P0UA),1 (I_3P5UA),2 (I_4P0UA),3 (I_4P5UA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_LDO_CURR                            = " "0 (I_0P5UA),1 (I_1P0UA),2 (I_1P5UA),3 (I_2P0UA)"
    tree.end
    tree "CDC_A_RX_HPH_CNP_EN"
      sgroup "CDC_A_RX_HPH_CNP_EN (at 0x1f197)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FSM_CLK_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FSM_RESET                                = " "0 (NORMAL_OP),1 (RESET)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HPH_PA_EN                                = " "0 (NONE),1 (HPHR),2 (HPHL),3 (HPHR_HPHL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_OVERRIDE_EN                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DBG_CURR_DIRECTION_L                     = " "0 (SINK),1 (SOURCE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DBG_CURR_DIRECTION_R                     = " "0 (SINK),1 (SOURCE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DBG_VREF_EN                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_HPH_CNP_WG_CTL"
      sgroup "CDC_A_RX_HPH_CNP_WG_CTL (at 0x1f198)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GM3_BOOST_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PWR_DN_SEQ_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   VREF_TIMER                               = " "0 (T_0US),1 (T_1X0P72US),2 (reserved),3 (T_3X0P72US),4 (reserved),5 (reserved),6 (reserved),7 (T_7X0P72US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURR_LDIV_CTL                            = " "0 (DIV_250),1 (DIV_333),2 (DIV_500),3 (DIV_1000),4 (reserved),5 (reserved),6 (reserved),7 (DIV_2000)"
    tree.end
    tree "CDC_A_RX_HPH_CNP_WG_TIME"
      sgroup "CDC_A_RX_HPH_CNP_WG_TIME (at 0x1f199)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   WG_FINE_TIMER                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_LDO_OUT                             = " "0 (V_2P6V),1 (V_2P8V),2 (V_3P0V),3 (VCM_3P2V)"
    tree.end
    tree "CDC_A_RX_HPH_L_TEST"
      sgroup "CDC_A_RX_HPH_L_TEST (at 0x1f19a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PA_BIAS_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PA_OUT2_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PA_OUT_EN                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PA_CNP_SW_CONN                           = " "0 (STATIC),1 (WAVEGEN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PA_CNP_SW_OVERRIDE_EN                    = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_DET_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ZDET_VDSOP                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ZDET_RFBOS                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_HPH_L_PA_DAC_CTL"
      sgroup "CDC_A_RX_HPH_L_PA_DAC_CTL (at 0x1f19b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   GM3_IBIAS_CTL                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DAC_DATA_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_SAMPLE_EDGE_SEL                      = " "0 (FALLING),1 (RISING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RESET                               = " "0 (NORMAL_OP),1 (RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INV_DATA                                 = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_HPH_R_TEST"
      sgroup "CDC_A_RX_HPH_R_TEST (at 0x1f19c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PA_BIAS_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PA_OUT2_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PA_OUT_EN                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PA_CNP_SW_CONN                           = " "0 (STATIC),1 (WAVEGEN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PA_CNP_SW_OVERRIDE_EN                    = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_DET_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ZDET_VDSOP                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ZDET_RFBOS                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_HPH_R_PA_DAC_CTL"
      sgroup "CDC_A_RX_HPH_R_PA_DAC_CTL (at 0x1f19d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   GM3_IBIAS_CTL                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DAC_DATA_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_SAMPLE_EDGE_SEL                      = " "0 (FALLING),1 (RISING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RESET                               = " "0 (NORMAL_OP),1 (RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INV_DATA                                 = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_RX_EAR_EN"
      sgroup "CDC_A_RX_EAR_EN (at 0x1f19e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PA_SEL                                   = " "0 (HPH),1 (EAR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EAR_PA_EN                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   GAIN                                     = " "0 (POS_1P5_DB_DI),1 (POS_6_DB_DI)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   EAR_CM_SEL                               = " "0 (VCM_1P5V),1 (VCM_1P56V),2 (VCM_1P6V),3 (VCM_1P65V)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   EAR_CMBUF_BIAS_CURR                      = " "0 (I_1P5UA),1 (I_2P0UA),2 (I_2P5UA),3 (I_3P0UA)"
    tree.end
    tree "CDC_A_RX_ATEST"
      sgroup "CDC_A_RX_ATEST (at 0x1f19f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f19f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf19f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PA_L_ATEST_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LDOL_ATEST2_CAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PA_R_ATEST_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LDOR_ATEST2_CAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DAC_ATEST_EN                             = " "0, 1"
    tree.end
    tree "CDC_A_RX_HPH_STATUS"
      sgroup "CDC_A_RX_HPH_STATUS (at 0x1f1a0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "CDC_A_RX_EAR_STATUS"
      sgroup "CDC_A_RX_EAR_STATUS (at 0x1f1a1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "CDC_A_SPKR_DAC_CTL"
      sgroup "CDC_A_SPKR_DAC_CTL (at 0x1f1b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DAC_GAIN                                 = " "0 (POS_0P00_DB),1 (POS_0P27_DB),2 (POS_0P54_DB),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DAC_RESET                                = " "0 (NORMAL),1 (RESET)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_POLARITY                             = " "0 (FALLING),1 (RISING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MCLK_SEL                                 = " "0 (MCLK),1 (NCPCLK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CAL_BYPASS                               = " "0 (BYPASS),1 (NORMAL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_4X_B                                 = " "0 (NORMAL_4XCLK),1 (NORMAL_CLK)"
    tree.end
    tree "CDC_A_SPKR_DRV_CLIP_DET"
      sgroup "CDC_A_SPKR_DRV_CLIP_DET (at 0x1f1b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLIP_LIMIT                               = " "0 (N_0),1 (N_1),2 (N_2),3 (N_3),4 (N_4),5 (N_5),6 (N_6),7 (N_7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   FIFO_LEN                                 = " "0 (N_1),1 (N_2),2 (N_3),3 (N_4),4 (N_5),5 (N_6),6 (N_7),7 (N_8)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLIP_MODE                                = " "0 (DISABLE),1 (ENABLE_CLIP_DET),2 (CNP_TEST_START_UP),3 (CNP_TEST_SHUT_DOWN)"
    tree.end
    tree "CDC_A_SPKR_DRV_CTL"
      sgroup "CDC_A_SPKR_DRV_CTL (at 0x1f1b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLASSD_PA_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_EN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SETTLE_EN                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_STATES                               = " "0 (PWM_3STATE),1 (PWM_2STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FW_EN                                    = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOOST_SET                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CMFB_SET                                 = " "0 (I_200UA),1 (I_300UA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GAIN_SET                                 = " "0 (G18DB),1 (G12DB)"
    tree.end
    tree "CDC_A_SPKR_ANA_BIAS_SET"
      sgroup "CDC_A_SPKR_ANA_BIAS_SET (at 0x1f1b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   INT1_CMFB_CURR                           = " "0 (I_9P00UA),1 (I_9P50UA),2 (I_10P00UA),3 (I_10P50UA),4 (I_11P00UA),5 (I_11P50UA),6 (I_12P00UA),7 (I_12UA50)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   SAR_DAC_CURR                             = " "0 (I_1P25UA),1 (I_1P50UA),2 (I_1P75UA),3 (I_2P00UA),4 (I_2P25UA),5 (I_2P50UA),6 (I_2P75UA),7 (I_30UA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT2_OPAMP_CURR                          = " "0 (I_7P00UA),1 (I_7P50UA),2 (I_8P00UA),3 (I_8P50UA)"
    tree.end
    tree "CDC_A_SPKR_OCP_CTL"
      sgroup "CDC_A_SPKR_OCP_CTL (at 0x1f1b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_HOLD                                 = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_CURR_LIMIT                           = " "0 (ZEROP5A),1 (TWOP5A),2 (THREEP0A),3 (FOURP0A)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GLITCH_FILTER                            = " "0 (T160NS),1 (T120NS),2 (T80NS),3 (T40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT2_SF_CURR                             = " "0 (I_10P00UA),1 (I_15P00UA),2 (I_20P00UA),3 (I_25P00UA)"
    tree.end
    tree "CDC_A_SPKR_PWRSTG_CTL"
      sgroup "CDC_A_SPKR_PWRSTG_CTL (at 0x1f1b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BBM_EN                                   = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HBRDGE_EN                                = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   DEADTIME                                 = " "0 (T20NS),1 (T15NS),2 (T10NS),3 (T05NS)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SLEW                                     = " "0 (T20NS),1 (T15NS),2 (T10NS),3 (T05NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DAC_EN                                   = " "0 (DIABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_SPKR_DRV_MISC"
      sgroup "CDC_A_SPKR_DRV_MISC (at 0x1f1b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CMP_CURR                                 = " "0 (I_2P25UA),1 (I_3P00UA),2 (I_3P50UA),3 (I_4P00UA),4 (I_4P50UA),5 (I_5P00UA),6 (I_5P50UA),7 (I_6P00UA)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INT1_OTA1_CURR                           = " "0 (I_14UA),1 (I_15UA),2 (I_16UA),3 (I_17UA)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   INT2_OTA2_CURR                           = " "0 (I_14UA),1 (I_15UA),2 (I_16UA),3 (I_17UA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_CLK_SEL                              = " "0 (CLK_600KHZ),1 (CLK_300KHZ)"
    tree.end
    tree "CDC_A_SPKR_DRV_DBG"
      sgroup "CDC_A_SPKR_DRV_DBG (at 0x1f1b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST_EN                                 = " "0 (DIABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_HBRDG_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HBRIDGE_LEFT_CTL                         = " "0 (PMOS_EN),1 (reserved),2 (reserved),3 (NMOS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HBRIDGE_RIGHT_CTL                        = " "0 (PMOS_EN),1 (reserved),2 (reserved),3 (NMOS_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATSEST_CTL                               = " "0 (DISABLE),1 (ATEST1_DAC1_ATEST2_DAC2_ATEST3_INTN_ATEST4_INTP),2 (reserved),3 (reserved)"
    tree.end
    tree "CDC_A_BOOST_CURRENT_LIMIT"
      sgroup "CDC_A_BOOST_CURRENT_LIMIT (at 0x1f1c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MAX_CURR_LIM_DISABLE                     = " "0 (ENABLE),1 (DISABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0 (I_0P5A),1 (I_1P0A),2 (I_1P5A),3 (I_2P0A),4 (I_2P5A),5 (I_3P0A),6 (I_3P5A),7 (I_4P0A)"
    tree.end
    tree "CDC_A_BOOST_OUTPUT_VOLTAGE"
      sgroup "CDC_A_BOOST_OUTPUT_VOLTAGE (at 0x1f1c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "CDC_A_BOOST_BYPASS_MODE"
      sgroup "CDC_A_BOOST_BYPASS_MODE (at 0x1f1c2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_BYPASS                           = " "0 (DISABLE_BYPASS),1 (BYPASS_PFET)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_FORCE                               = " "0 (FORCE_PFET_OFF),1 (FORCE_PFET_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_NFET_BYPASS                           = " "0 (PWM_CTL_NFET),1 (EXTERNAL_CTL_NFET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_FORCE                               = " "0 (FORCE_NFET_OFF),1 (FORCE_NFET_ON)"
    tree.end
    tree "CDC_A_BOOST_EN_CTL"
      sgroup "CDC_A_BOOST_EN_CTL (at 0x1f1c3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOST_ENABLE                             = " "0 (MODULE_DISABLE),1 (MODULE_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PULSE_SKIP_MODE                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PULSE_SKIP_THRES                         = " "0 (PULSESKIP_THRES_50MA),1 (PULSESKIP_THRES_100MA),2 (PULSESKIP_THRES_150MA),3 (PULSESKIP_THRES_200MA)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LOOP_COMP_CAP                            = " "0 (C_40PF),1 (C_60PF),2 (C_80PF),3 (C_100PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (R_100K),1 (R_200K),2 (R_500K),3 (R_600K)"
    tree.end
    tree "CDC_A_SLOPE_COMP_IP_ZERO"
      sgroup "CDC_A_SLOPE_COMP_IP_ZERO (at 0x1f1c4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   SLOPE_COMP_CURRNET                       = " "0 (I_4P5UA),1 (I_4P0UA),2 (I_3P5UA),3 (I_3P0UA),4 (I_2P5UA),5 (I_2P0UA),6 (I_1P5UA),7 (I_1P0UA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_DOUBLER                       = " "0 (DOUBLE),1 (NO_DOUBLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ZX_DETECT_ON                             = " "0 (FORCE_IP_ZERO_DETETOR_OUPUT_ZERO),1 (ENABLE_IP_ZERO_DETECTION)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTOZERO_ON                              = " "0 (AUTO_ZERO_WHEN_PFET_OFF),1 (NO_AUTO_ZERO)"
    tree.end
    tree "CDC_A_RDSON_MAX_DUTY_CYCLE"
      sgroup "CDC_A_RDSON_MAX_DUTY_CYCLE (at 0x1f1c5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NFET_SW_SIZE                             = " "0 (TWOBY3_FULL_SIZE),1 (FULL_SIZE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_MAX_DUTY_CYCLE                        = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_BOOST_TEST_1"
      sgroup "CDC_A_BOOST_TEST_1 (at 0x1f1c6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_CTL                                = " "0 (NO_SIG),1 (ERR_AMP_OUT),2 (NFET_DSNS),3 (NFET_SSNS),4 (INT_REF_SIG_1V),5 (PVDD_DLOW),6 (PVDD_D0P25),7 (VREF_PS)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   DTEST_CTL                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_EN                                 = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_A_BOOST_TEST_2"
      sgroup "CDC_A_BOOST_TEST_2 (at 0x1f1c7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_BYPASS                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DUTY_MODULATION                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_SEL                                  = " "0 (PMIC),1 (ANALOG)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CUR_COMP_OFFSET                          = " "0 (NEG_ZERO),1 (NEG_1P5MV),2 (NEG_3P0MV),3 (NEG_4P5MV)"
    tree.end
    tree "CDC_A_SPKR_SAR_STATUS"
      sgroup "CDC_A_SPKR_SAR_STATUS (at 0x1f1c8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SAR_ADC                                  = "
    tree.end
    tree "CDC_A_SPKR_DRV_STATUS"
      sgroup "CDC_A_SPKR_DRV_STATUS (at 0x1f1c9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_STOP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   POS_PMOS_OCP_1                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   POS_NMOS_OCP_2                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NEG_PMOS_OCP_1                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NEG_NMOS_OCP_2                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLIP_DET_P                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLIP_DET_N                               = " "0, 1"
    tree.end
    tree "CDC_A_PBUS_ADD_CSR"
      sgroup "CDC_A_PBUS_ADD_CSR (at 0x1f1ce)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1ce0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1ce0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REG                                      = "
    tree.end
    tree "CDC_A_PBUS_ADD_SEL"
      sgroup "CDC_A_PBUS_ADD_SEL (at 0x1f1cf)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1cf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1cf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REG                                      = " "0, 1"
    tree.end
    tree "CDC_A_SEC_ACCESS"
      sgroup "CDC_A_SEC_ACCESS (at 0x1f1d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CDC_A_PERPH_RESET_CTL1"
      sgroup "CDC_A_PERPH_RESET_CTL1 (at 0x1f1d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "CDC_A_PERPH_RESET_CTL2"
      sgroup "CDC_A_PERPH_RESET_CTL2 (at 0x1f1d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CDC_A_PERPH_RESET_CTL3"
      sgroup "CDC_A_PERPH_RESET_CTL3 (at 0x1f1da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CDC_A_PERPH_RESET_CTL4"
      sgroup "CDC_A_PERPH_RESET_CTL4 (at 0x1f1db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CDC_A_INT_TEST1"
      sgroup "CDC_A_INT_TEST1 (at 0x1f1e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "CDC_A_INT_TEST_VAL"
      sgroup "CDC_A_INT_TEST_VAL (at 0x1f1e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   D_CDC_HPHL_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   D_CDC_HPHR_CNP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_CDC_EAR_CNP_INT                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_HPHL_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_HPHR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_EAR_OCP_INT                        = " "0, 1"
    tree.end
    tree "CDC_A_TRIM_NUM"
      sgroup "CDC_A_TRIM_NUM (at 0x1f1f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CDC_A_TRIM_CTRL1"
      sgroup "CDC_A_TRIM_CTRL1 (at 0x1f1f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_CTRL1                               = "
    tree.end
    tree "CDC_A_TRIM_CTRL2"
      sgroup "CDC_A_TRIM_CTRL2 (at 0x1f1f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_CTRL2                               = "
    tree.end
    tree "CDC_A_TRIM_CTRL3"
      sgroup "CDC_A_TRIM_CTRL3 (at 0x1f1f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_CTRL3                               = "
    tree.end
    tree "CDC_A_TRIM_CTRL4"
      sgroup "CDC_A_TRIM_CTRL4 (at 0x1f1f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        set &access:&cmd_addr %l 0x80f1f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf1f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_CTRL4                               = "
    tree.end
  tree.end
tree.end
tree "CDC_BOOST_FREQ"
  tree "CDC_BOOST_FREQ"
    tree "CDC_BOOST_FREQ_REVISION1"
      sgroup "CDC_BOOST_FREQ_REVISION1 (at 0x1f200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CDC_BOOST_FREQ_REVISION2"
      sgroup "CDC_BOOST_FREQ_REVISION2 (at 0x1f201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CDC_BOOST_FREQ_PERPH_TYPE"
      sgroup "CDC_BOOST_FREQ_PERPH_TYPE (at 0x1f204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CDC_BOOST_FREQ_PERPH_SUBTYPE"
      sgroup "CDC_BOOST_FREQ_PERPH_SUBTYPE (at 0x1f205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CDC_BOOST_FREQ_CLK_ENABLE"
      sgroup "CDC_BOOST_FREQ_CLK_ENABLE (at 0x1f246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "CDC_BOOST_FREQ_CLK_DIV"
      sgroup "CDC_BOOST_FREQ_CLK_DIV (at 0x1f250)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "CDC_BOOST_FREQ_CLK_PHASE"
      sgroup "CDC_BOOST_FREQ_CLK_PHASE (at 0x1f251)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "CDC_BOOST_FREQ_GANG_CTL1"
      sgroup "CDC_BOOST_FREQ_GANG_CTL1 (at 0x1f2c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "CDC_BOOST_FREQ_GANG_CTL2"
      sgroup "CDC_BOOST_FREQ_GANG_CTL2 (at 0x1f2c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "CDC_BOOST_FREQ_SEC_ACCESS"
      sgroup "CDC_BOOST_FREQ_SEC_ACCESS (at 0x1f2d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CDC_BOOST_FREQ_PERPH_RESET_CTL2"
      sgroup "CDC_BOOST_FREQ_PERPH_RESET_CTL2 (at 0x1f2d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CDC_BOOST_FREQ_PERPH_RESET_CTL3"
      sgroup "CDC_BOOST_FREQ_PERPH_RESET_CTL3 (at 0x1f2da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CDC_BOOST_FREQ_PERPH_RESET_CTL4"
      sgroup "CDC_BOOST_FREQ_PERPH_RESET_CTL4 (at 0x1f2db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "CDC_BOOST_FREQ_TEST1"
      sgroup "CDC_BOOST_FREQ_TEST1 (at 0x1f2e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        set &access:&cmd_addr %l 0x80f2e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf2e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "CDC_D"
  tree "CDC_D"
    tree "CDC_D_REVISION1"
      sgroup "CDC_D_REVISION1 (at 0x1f000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CDC_D_REVISION2"
      sgroup "CDC_D_REVISION2 (at 0x1f001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CDC_D_PERPH_TYPE"
      sgroup "CDC_D_PERPH_TYPE (at 0x1f004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CDC_D_PERPH_SUBTYPE"
      sgroup "CDC_D_PERPH_SUBTYPE (at 0x1f005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CDC_D_INT_RT_STS"
      sgroup "CDC_D_INT_RT_STS (at 0x1f010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_SET_TYPE"
      sgroup "CDC_D_INT_SET_TYPE (at 0x1f011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_POLARITY_HIGH"
      sgroup "CDC_D_INT_POLARITY_HIGH (at 0x1f012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_POLARITY_LOW"
      sgroup "CDC_D_INT_POLARITY_LOW (at 0x1f013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_LATCHED_CLR"
      sgroup "CDC_D_INT_LATCHED_CLR (at 0x1f014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_EN_SET"
      sgroup "CDC_D_INT_EN_SET (at 0x1f015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_EN_CLR"
      sgroup "CDC_D_INT_EN_CLR (at 0x1f016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_LATCHED_STS"
      sgroup "CDC_D_INT_LATCHED_STS (at 0x1f018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_PENDING_STS"
      sgroup "CDC_D_INT_PENDING_STS (at 0x1f019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_INT_MID_SEL"
      sgroup "CDC_D_INT_MID_SEL (at 0x1f01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "CDC_D_INT_PRIORITY"
      sgroup "CDC_D_INT_PRIORITY (at 0x1f01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "CDC_D_GPIO_MODE"
      sgroup "CDC_D_GPIO_MODE (at 0x1f040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_MODE                                = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_D_PIN_CTL_OE"
      sgroup "CDC_D_PIN_CTL_OE (at 0x1f041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PIN_CTL_OE0                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_D_PIN_CTL_DATA"
      sgroup "CDC_D_PIN_CTL_DATA (at 0x1f042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CTL_DATA0                                = " "0, 1"
    tree.end
    tree "CDC_D_PIN_STATUS"
      sgroup "CDC_D_PIN_STATUS (at 0x1f043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PAD_STATUS4                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PAD_STATUS3                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PAD_STATUS2                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PAD_STATUS1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PAD_STATUS0                              = " "0, 1"
    tree.end
    tree "CDC_D_HDRIVE_CTL"
      sgroup "CDC_D_HDRIVE_CTL (at 0x1f044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HDRIVE_CTL                               = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "CDC_D_CDC_RST_CTL"
      sgroup "CDC_D_CDC_RST_CTL (at 0x1f046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_SW_RST_N                             = " "0 (RESET),1 (REMOVE_RESET)"
    tree.end
    tree "CDC_D_CDC_TOP_CLK_CTL"
      sgroup "CDC_D_CDC_TOP_CLK_CTL (at 0x1f048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   A_MCLK2_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   A_MCLK_EN                                = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_D_CDC_ANA_CLK_CTL"
      sgroup "CDC_D_CDC_ANA_CLK_CTL (at 0x1f049)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TXA_CLK25_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPKR_CLK_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EAR_HPHL_CLK_EN                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EAR_HPHR_CLK_EN                          = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_D_CDC_DIG_CLK_CTL"
      sgroup "CDC_D_CDC_DIG_CLK_CTL (at 0x1f04a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RXD_PDM_CLK_EN                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   NCP_CLK_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BOOST_CLK_EN                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TXD_CLK_EN                               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   D_MBHC_CLK_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RXD3_CLK_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RXD2_CLK_EN                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RXD1_CLK_EN                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "CDC_D_CDC_CONN_TX1_CTL"
      sgroup "CDC_D_CDC_CONN_TX1_CTL (at 0x1f050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SERIAL_TX1_MUX                           = " "0 (ADC_1),1 (RX_PDM_LB),2 (ZERO),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_CONN_TX2_CTL"
      sgroup "CDC_D_CDC_CONN_TX2_CTL (at 0x1f051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SERIAL_TX2_MUX                           = " "0 (ADC_2),1 (RX_PDM_LB),2 (ZERO),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_CONN_HPHR_DAC_CTL"
      sgroup "CDC_D_CDC_CONN_HPHR_DAC_CTL (at 0x1f052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RX_SEL                                   = " "0 (RX1),1 (RX2)"
    tree.end
    tree "CDC_D_CDC_CONN_RX1_CTL"
      sgroup "CDC_D_CDC_CONN_RX1_CTL (at 0x1f053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RX1_INP_SEL                              = " "0 (RX1),1 (TX_LB_ADC1),2 (TX_LB_ADC2),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_CONN_RX2_CTL"
      sgroup "CDC_D_CDC_CONN_RX2_CTL (at 0x1f054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RX2_INP_SEL                              = " "0 (RX2),1 (TX_LB_ADC1),2 (TX_LB_ADC2),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_CONN_RX3_CTL"
      sgroup "CDC_D_CDC_CONN_RX3_CTL (at 0x1f055)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RX3_INP_SEL                              = " "0 (RX3),1 (TX_LB_ADC1),2 (TX_LB_ADC2),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_CONN_RX_LB_CTL"
      sgroup "CDC_D_CDC_CONN_RX_LB_CTL (at 0x1f056)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RX_LB_SEL                                = " "0 (RX1_FIR_DATA),1 (RX2_FIR_DATA),2 (RX3_FIR_DATA),3 (reserved)"
    tree.end
    tree "CDC_D_CDC_RX_CTL1"
      sgroup "CDC_D_CDC_RX_CTL1 (at 0x1f058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEM_DITHER_ENABLE                        = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEM_MID_ENABLE                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEM_MOD_SWITCHING_BLOCK_ENABLE           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEM_SWITCHING_BLOCK_ENABLE               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEM_SEGMENTING_BLOCK_ENABLE              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEM_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FIR_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
    tree.end
    tree "CDC_D_CDC_RX_CTL2"
      sgroup "CDC_D_CDC_RX_CTL2 (at 0x1f059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEM_DITHER_ENABLE                        = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEM_MID_ENABLE                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEM_MOD_SWITCHING_BLOCK_ENABLE           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEM_SWITCHING_BLOCK_ENABLE               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEM_SEGMENTING_BLOCK_ENABLE              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEM_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FIR_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
    tree.end
    tree "CDC_D_CDC_RX_CTL3"
      sgroup "CDC_D_CDC_RX_CTL3 (at 0x1f05a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f05a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf05a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEM_DITHER_ENABLE                        = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEM_MID_ENABLE                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEM_MOD_SWITCHING_BLOCK_ENABLE           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEM_SWITCHING_BLOCK_ENABLE               = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEM_SEGMENTING_BLOCK_ENABLE              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEM_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FIR_BYPASS                               = " "0 (NO_BYPASS),1 (BYPASS)"
    tree.end
    tree "CDC_D_DEM_BYPASS_DATA0"
      sgroup "CDC_D_DEM_BYPASS_DATA0 (at 0x1f05b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f05b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf05b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEM_BYPASS_DATA0                         = "
    tree.end
    tree "CDC_D_DEM_BYPASS_DATA1"
      sgroup "CDC_D_DEM_BYPASS_DATA1 (at 0x1f05c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f05c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEM_BYPASS_DATA0                         = "
    tree.end
    tree "CDC_D_DEM_BYPASS_DATA2"
      sgroup "CDC_D_DEM_BYPASS_DATA2 (at 0x1f05d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f05d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf05d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEM_BYPASS_DATA0                         = "
    tree.end
    tree "CDC_D_DEM_BYPASS_DATA3"
      sgroup "CDC_D_DEM_BYPASS_DATA3 (at 0x1f05e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f05e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEM_BYPASS_DATA0                         = " "0, 1, 2, 3"
    tree.end
    tree "CDC_D_DIG_DEBUG_CTL"
      sgroup "CDC_D_DIG_DEBUG_CTL (at 0x1f068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DIG_DEBUG_CTL                            = "
    tree.end
    tree "CDC_D_DIG_DEBUG_EN"
      sgroup "CDC_D_DIG_DEBUG_EN (at 0x1f069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DIG_DEBUG_EN                             = "
    tree.end
    tree "CDC_D_SPARE_0"
      sgroup "CDC_D_SPARE_0 (at 0x1f070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE_REG_0                              = "
    tree.end
    tree "CDC_D_SPARE_1"
      sgroup "CDC_D_SPARE_1 (at 0x1f071)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE_REG_1                              = "
    tree.end
    tree "CDC_D_SPARE_2"
      sgroup "CDC_D_SPARE_2 (at 0x1f072)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE_REG_2                              = "
    tree.end
    tree "CDC_D_SEC_ACCESS"
      sgroup "CDC_D_SEC_ACCESS (at 0x1f0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CDC_D_PERPH_RESET_CTL1"
      sgroup "CDC_D_PERPH_RESET_CTL1 (at 0x1f0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "CDC_D_PERPH_RESET_CTL2"
      sgroup "CDC_D_PERPH_RESET_CTL2 (at 0x1f0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CDC_D_PERPH_RESET_CTL3"
      sgroup "CDC_D_PERPH_RESET_CTL3 (at 0x1f0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CDC_D_PERPH_RESET_CTL4"
      sgroup "CDC_D_PERPH_RESET_CTL4 (at 0x1f0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CDC_D_INT_TEST1"
      sgroup "CDC_D_INT_TEST1 (at 0x1f0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "CDC_D_INT_TEST_VAL"
      sgroup "CDC_D_INT_TEST_VAL (at 0x1f0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBHC_SWITCH_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBHC_MIC_ELECTRICAL_INS_REM_DET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBHC_BUTTON_PRESS_DET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBHC_BUTTON_RELEASE_DET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MBHC_MIC_ELECTRICAL_INS_REM_DET1         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   D_CDC_SPKR_OCP_INT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   D_CDC_SPKR_CLIP_INT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   D_CDC_SPKR_CNP_INT                       = " "0, 1"
    tree.end
    tree "CDC_D_TRIM_NUM"
      sgroup "CDC_D_TRIM_NUM (at 0x1f0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CDC_D_TRIM_CTRL"
      sgroup "CDC_D_TRIM_CTRL (at 0x1f0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        set &access:&cmd_addr %l 0x80f0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "CDC_NCP_FREQ"
  tree "CDC_NCP_FREQ"
    tree "CDC_NCP_FREQ_REVISION1"
      sgroup "CDC_NCP_FREQ_REVISION1 (at 0x1f300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CDC_NCP_FREQ_REVISION2"
      sgroup "CDC_NCP_FREQ_REVISION2 (at 0x1f301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CDC_NCP_FREQ_PERPH_TYPE"
      sgroup "CDC_NCP_FREQ_PERPH_TYPE (at 0x1f304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CDC_NCP_FREQ_PERPH_SUBTYPE"
      sgroup "CDC_NCP_FREQ_PERPH_SUBTYPE (at 0x1f305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CDC_NCP_FREQ_CLK_ENABLE"
      sgroup "CDC_NCP_FREQ_CLK_ENABLE (at 0x1f346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "CDC_NCP_FREQ_CLK_DIV"
      sgroup "CDC_NCP_FREQ_CLK_DIV (at 0x1f350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "CDC_NCP_FREQ_CLK_PHASE"
      sgroup "CDC_NCP_FREQ_CLK_PHASE (at 0x1f351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "CDC_NCP_FREQ_GANG_CTL1"
      sgroup "CDC_NCP_FREQ_GANG_CTL1 (at 0x1f3c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "CDC_NCP_FREQ_GANG_CTL2"
      sgroup "CDC_NCP_FREQ_GANG_CTL2 (at 0x1f3c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "CDC_NCP_FREQ_SEC_ACCESS"
      sgroup "CDC_NCP_FREQ_SEC_ACCESS (at 0x1f3d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CDC_NCP_FREQ_PERPH_RESET_CTL2"
      sgroup "CDC_NCP_FREQ_PERPH_RESET_CTL2 (at 0x1f3d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CDC_NCP_FREQ_PERPH_RESET_CTL3"
      sgroup "CDC_NCP_FREQ_PERPH_RESET_CTL3 (at 0x1f3da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CDC_NCP_FREQ_PERPH_RESET_CTL4"
      sgroup "CDC_NCP_FREQ_PERPH_RESET_CTL4 (at 0x1f3db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "CDC_NCP_FREQ_TEST1"
      sgroup "CDC_NCP_FREQ_TEST1 (at 0x1f3e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        set &access:&cmd_addr %l 0x80f3e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xf300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xf3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "COIN"
  tree "COIN"
    tree "COIN_REVISION1"
      sgroup "COIN_REVISION1 (at 0x2800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "COIN_REVISION2"
      sgroup "COIN_REVISION2 (at 0x2801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "COIN_REVISION3"
      sgroup "COIN_REVISION3 (at 0x2802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "COIN_REVISION4"
      sgroup "COIN_REVISION4 (at 0x2803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "COIN_PERPH_TYPE"
      sgroup "COIN_PERPH_TYPE (at 0x2804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "COIN_PERPH_SUBTYPE"
      sgroup "COIN_PERPH_SUBTYPE (at 0x2805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "COIN_STATUS1"
      sgroup "COIN_STATUS1 (at 0x2808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_OK                              = " "0 (CC_DISABLED),1 (CC_ENABLED)"
    tree.end
    tree "COIN_COIN_CHG_RSET"
      sgroup "COIN_COIN_CHG_RSET (at 0x2844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET                            = " "0 (CC_RSET_2K1),1 (CC_RSET_1K7),2 (CC_RSET_1K2),3 (CC_RSET_0K8)"
    tree.end
    tree "COIN_COIN_CHG_VSET"
      sgroup "COIN_COIN_CHG_VSET (at 0x2845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_VSET                            = " "0 (CC_VSET_2V5),1 (CC_VSET_3V2),2 (CC_VSET_3V1),3 (CC_VSET_3V0)"
    tree.end
    tree "COIN_EN_CTL"
      sgroup "COIN_EN_CTL (at 0x2846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_EN                              = " "0 (CC_DISABLED),1 (CC_ENABLED)"
    tree.end
    tree "COIN_SEC_ACCESS"
      sgroup "COIN_SEC_ACCESS (at 0x28d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "COIN_PERPH_RESET_CTL2"
      sgroup "COIN_PERPH_RESET_CTL2 (at 0x28d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL3"
      sgroup "COIN_PERPH_RESET_CTL3 (at 0x28da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL4"
      sgroup "COIN_PERPH_RESET_CTL4 (at 0x28db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "COIN_TEST_CTRL"
      sgroup "COIN_TEST_CTRL (at 0x28e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_VCOIN                               = " "0 (CC_TEST_MODE_DISABLED),1 (CC_TEST_MODE_ENABLED)"
    tree.end
    tree "COIN_TRIM_NUM"
      sgroup "COIN_TRIM_NUM (at 0x28f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_NUM                                 = " "0, 1"
    tree.end
    tree "COIN_TRIM_OFFSET"
      sgroup "COIN_TRIM_OFFSET (at 0x28f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET_TRIM                       = " "0 (reserved),1 (CC_RSET_MINUS_254),2 (CC_RESET_NOM),3 (CC_RSET_PLUS_227)"
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      sgroup "GPIO1_DIG_IN_CTL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      sgroup "GPIO1_DIG_OUT_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      sgroup "GPIO2_DIG_IN_CTL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      sgroup "GPIO2_DIG_OUT_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      sgroup "GPIO3_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      sgroup "GPIO3_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      sgroup "GPIO3_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      sgroup "GPIO3_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      sgroup "GPIO3_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      sgroup "GPIO3_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      sgroup "GPIO3_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      sgroup "GPIO3_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      sgroup "GPIO3_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      sgroup "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      sgroup "GPIO3_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      sgroup "GPIO3_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      sgroup "GPIO3_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      sgroup "GPIO3_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      sgroup "GPIO3_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      sgroup "GPIO3_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      sgroup "GPIO3_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      sgroup "GPIO3_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      sgroup "GPIO3_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      sgroup "GPIO3_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      sgroup "GPIO3_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      sgroup "GPIO3_DIG_IN_CTL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      sgroup "GPIO3_DIG_OUT_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO3_EN_CTL"
      sgroup "GPIO3_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      sgroup "GPIO3_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      sgroup "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      sgroup "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      sgroup "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      sgroup "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      sgroup "GPIO4_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      sgroup "GPIO4_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      sgroup "GPIO4_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      sgroup "GPIO4_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      sgroup "GPIO4_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      sgroup "GPIO4_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      sgroup "GPIO4_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      sgroup "GPIO4_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      sgroup "GPIO4_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      sgroup "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      sgroup "GPIO4_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      sgroup "GPIO4_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      sgroup "GPIO4_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      sgroup "GPIO4_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      sgroup "GPIO4_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      sgroup "GPIO4_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      sgroup "GPIO4_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      sgroup "GPIO4_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      sgroup "GPIO4_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      sgroup "GPIO4_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      sgroup "GPIO4_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      sgroup "GPIO4_DIG_IN_CTL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      sgroup "GPIO4_DIG_OUT_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO4_EN_CTL"
      sgroup "GPIO4_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      sgroup "GPIO4_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      sgroup "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      sgroup "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      sgroup "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      sgroup "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LBC_BAT_IF"
  tree "LBC_BAT_IF"
    tree "LBC_BAT_IF_PERPH_TYPE"
      sgroup "LBC_BAT_IF_PERPH_TYPE (at 0x1204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LBC_BAT_IF_PERPH_SUBTYPE"
      sgroup "LBC_BAT_IF_PERPH_SUBTYPE (at 0x1205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LBC_BAT_IF_BAT_PRES_STATUS"
      sgroup "LBC_BAT_IF_BAT_PRES_STATUS (at 0x1208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_PRES                                 = " "0 (BATTERY_GONE),1 (BATTERY_PRESENT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_REMOVED_OFFMODE                      = " "0 (BATTERY_NEVER_REMOVED),1 (BATTERY_WAS_REMOVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_THM_PRES                             = " "0 (BAT_THM_GONE),1 (BAT_THM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_ID_PRES                              = " "0 (BAT_ID_GONE),1 (BAT_ID_PRESENT)"
    tree.end
    tree "LBC_BAT_IF_BAT_TEMP_STATUS"
      sgroup "LBC_BAT_IF_BAT_TEMP_STATUS (at 0x1209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BAT_TEMP                                 = " "0 (BAT_TEMP_TOO_COLD),1 (BAT_TEMP_TOO_HOT),2 (BAT_TEMP_OK),3 (BAT_TEMP_OK_3)"
    tree.end
    tree "LBC_BAT_IF_VREF_BAT_THM_STATUS"
      sgroup "LBC_BAT_IF_VREF_BAT_THM_STATUS (at 0x120a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80120a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x120a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_BAT_THM_ON                          = " "0 (VREF_BAT_THM_OFF),1 (VREF_BAT_THM_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOURCE_AVDD                              = " "0 (NO),1 (YES)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOURCE_VADC                              = " "0 (NO),1 (YES)"
    tree.end
    tree "LBC_BAT_IF_INT_RT_STS"
      sgroup "LBC_BAT_IF_INT_RT_STS (at 0x1210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "LBC_BAT_IF_INT_SET_TYPE"
      sgroup "LBC_BAT_IF_INT_SET_TYPE (at 0x1211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LBC_BAT_IF_INT_POLARITY_HIGH"
      sgroup "LBC_BAT_IF_INT_POLARITY_HIGH (at 0x1212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_INT_POLARITY_LOW"
      sgroup "LBC_BAT_IF_INT_POLARITY_LOW (at 0x1213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_INT_LATCHED_CLR"
      sgroup "LBC_BAT_IF_INT_LATCHED_CLR (at 0x1214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_INT_EN_SET"
      sgroup "LBC_BAT_IF_INT_EN_SET (at 0x1215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_INT_EN_CLR"
      sgroup "LBC_BAT_IF_INT_EN_CLR (at 0x1216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_INT_LATCHED_STS"
      sgroup "LBC_BAT_IF_INT_LATCHED_STS (at 0x1218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LBC_BAT_IF_INT_PENDING_STS"
      sgroup "LBC_BAT_IF_INT_PENDING_STS (at 0x1219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LBC_BAT_IF_INT_MID_SEL"
      sgroup "LBC_BAT_IF_INT_MID_SEL (at 0x121a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LBC_BAT_IF_INT_PRIORITY"
      sgroup "LBC_BAT_IF_INT_PRIORITY (at 0x121b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LBC_BAT_IF_BPD_CTRL"
      sgroup "LBC_BAT_IF_BPD_CTRL (at 0x1248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BPD_OFFMODE_EN                           = " "0 (BPD_OFFMODE_DISABLED),1 (BPD_OFFMODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATID_BATTHM_B_SEL                       = " "0 (BAT_THM),1 (BAT_ID)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_THM_EN                               = " "0 (BPD_BAT_THM_DISABLED),1 (BPD_BAT_THM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_ID_EN                                = " "0 (BPD_BAT_ID_DISABLED),1 (BPD_BAT_ID_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_BTC_CTRL"
      sgroup "LBC_BAT_IF_BTC_CTRL (at 0x1249)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TEMP_COMP_EN                         = " "0 (BTC_DISABLED),1 (BTC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_COLD_THD                        = " "0 (COLD_THD_70_PCT),1 (COLD_THD_80_PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_HOT_THD                         = " "0 (HOT_THD_25_PCT),1 (HOT_THD_35_PCT)"
    tree.end
    tree "LBC_BAT_IF_VREF_BAT_THM_CTRL"
      sgroup "LBC_BAT_IF_VREF_BAT_THM_CTRL (at 0x124a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80124a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x124a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   EN                                       = " "0 (VREF_BAT_THM_DISABLED),1 (VREF_BAT_THM_DISABLED_1),2 (VREF_BAT_THM_ENABLED_FSM),3 (VREF_BAT_THM_FORCED_ON)"
    tree.end
    tree "LBC_BAT_IF_BAT_REMOVED_OFFMODE"
      sgroup "LBC_BAT_IF_BAT_REMOVED_OFFMODE (at 0x124f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80124f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x124f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLR                                      = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_SEC_ACCESS"
      sgroup "LBC_BAT_IF_SEC_ACCESS (at 0x12d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LBC_BAT_IF_PERPH_RESET_CTL2"
      sgroup "LBC_BAT_IF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_PERPH_RESET_CTL3"
      sgroup "LBC_BAT_IF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_PERPH_RESET_CTL4"
      sgroup "LBC_BAT_IF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_BAT_IF_PERPH_RESET_CTL5"
      sgroup "LBC_BAT_IF_PERPH_RESET_CTL5 (at 0x12dc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012dc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12dc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_PERPH_RESET_CTL6"
      sgroup "LBC_BAT_IF_PERPH_RESET_CTL6 (at 0x12dd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012dd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12dd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_BAT_IF_BAT_IF_SPARE"
      sgroup "LBC_BAT_IF_BAT_IF_SPARE (at 0x12df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "LBC_BAT_IF_INT_TEST1"
      sgroup "LBC_BAT_IF_INT_TEST1 (at 0x12e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LBC_BAT_IF_INT_TEST_VAL"
      sgroup "LBC_BAT_IF_INT_TEST_VAL (at 0x12e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_PRES_INT_VAL                        = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_BAT_IF_TEST1"
      sgroup "LBC_BAT_IF_BAT_IF_TEST1 (at 0x12e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BPD_OFFMODE_SPEEDUP                      = " "0, 1"
    tree.end
    tree "LBC_BAT_IF_COMP_OVR0"
      sgroup "LBC_BAT_IF_COMP_OVR0 (at 0x12e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BAT_TOO_COLD                             = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BAT_TOO_HOT                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_GONE                                 = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_BAT_IF_COMP_OVR1"
      sgroup "LBC_BAT_IF_COMP_OVR1 (at 0x12e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BPD_OFFMODE_COMP                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_XOADC                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_BAT_IF_BAT_IF_COMP_OVR_GLOBAL"
      sgroup "LBC_BAT_IF_BAT_IF_COMP_OVR_GLOBAL (at 0x12e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
  tree.end
tree.end
tree "LBC_CHGR"
  tree "LBC_CHGR"
    tree "LBC_CHGR_PERPH_TYPE"
      sgroup "LBC_CHGR_PERPH_TYPE (at 0x1004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LBC_CHGR_PERPH_SUBTYPE"
      sgroup "LBC_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LBC_CHGR_CHG_OPTION"
      sgroup "LBC_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0 (EXT_CHARGER),1 (PMIC_CHARGER)"
    tree.end
    tree "LBC_CHGR_CHG_STATUS"
      sgroup "LBC_CHGR_CHG_STATUS (at 0x1009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERM_LOOP                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VIN_MIN_LOOP                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICHG_LOOP                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VDD_LOOP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_ON                                   = " "0, 1"
    tree.end
    tree "LBC_CHGR_ATC_STATUS"
      sgroup "LBC_CHGR_ATC_STATUS (at 0x100a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATC_DONE                                 = " "0 (ATC_NOT_DONE),1 (ATC_DONE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATC_FAILED                               = " "0 (ATC_NOT_FAILED),1 (ATC_FAILED)"
    tree.end
    tree "LBC_CHGR_VBAT_STATUS"
      sgroup "LBC_CHGR_VBAT_STATUS (at 0x100b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ABOVE_VBATDET_LO                         = " "0 (BELOW_VBATDET_LO),1 (ABOVE_VBATDET_LO)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ABOVE_VBAT_WEAK                          = " "0 (BELOW_VBAT_WEAK),1 (ABOVE_VBAT_WEAK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABOVE_VBAT_TRKL                          = " "0 (BELOW_VBAT_TRKL),1 (ABOVE_VBAT_TRKL)"
    tree.end
    tree "LBC_CHGR_INT_RT_STS"
      sgroup "LBC_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_RT_STS                        = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "LBC_CHGR_INT_SET_TYPE"
      sgroup "LBC_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LBC_CHGR_INT_POLARITY_HIGH"
      sgroup "LBC_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_POLARITY_HIGH                 = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_CHGR_INT_POLARITY_LOW"
      sgroup "LBC_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_POLARITY_LOW                  = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_CHGR_INT_LATCHED_CLR"
      sgroup "LBC_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "LBC_CHGR_INT_EN_SET"
      sgroup "LBC_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_CHGR_INT_EN_CLR"
      sgroup "LBC_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_CHGR_INT_LATCHED_STS"
      sgroup "LBC_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LBC_CHGR_INT_PENDING_STS"
      sgroup "LBC_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LBC_CHGR_INT_MID_SEL"
      sgroup "LBC_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LBC_CHGR_INT_PRIORITY"
      sgroup "LBC_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LBC_CHGR_VDD_MAX"
      sgroup "LBC_CHGR_VDD_MAX (at 0x1040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_VDD_SAFE"
      sgroup "LBC_CHGR_VDD_SAFE (at 0x1041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_VDDMAX_GSM_ADJ"
      sgroup "LBC_CHGR_VDDMAX_GSM_ADJ (at 0x1043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (FEATURE_DISABLED),1 (FEATURE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MUX_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SEL                                      = " "0 (ADJ_0MV),1 (ADJ_25MV),2 (ADJ_50MV),3 (ADJ_75MV),4 (ADJ_100MV),5 (ADJ_125MV),6 (ADJ_150MV),7 (ADJ_175MV)"
    tree.end
    tree "LBC_CHGR_IBAT_MAX"
      sgroup "LBC_CHGR_IBAT_MAX (at 0x1044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_IBAT_SAFE"
      sgroup "LBC_CHGR_IBAT_SAFE (at 0x1045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_VIN_MIN"
      sgroup "LBC_CHGR_VIN_MIN (at 0x1047)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_CHG_CTRL"
      sgroup "LBC_CHGR_CHG_CTRL (at 0x1049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN                                   = " "0 (CHG_DISABLED),1 (CHG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_PAUSE                                = " "0 (CHG_NOT_PAUSED),1 (CHG_PAUSED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PSTG_EN                                  = " "0 (CHG_PSTG_NOT_FORCED_ON),1 (CHG_PSTG_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ON_BAT_FORCE                             = " "0 (NOT_FORCED_ON_BAT),1 (FORCED_ON_BAT)"
    tree.end
    tree "LBC_CHGR_CHG_FAILED"
      sgroup "LBC_CHGR_CHG_FAILED (at 0x104a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80104a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x104a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "LBC_CHGR_ATC_FAILED"
      sgroup "LBC_CHGR_ATC_FAILED (at 0x104c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80104c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x104c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "LBC_CHGR_LED"
      sgroup "LBC_CHGR_LED (at 0x104d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80104d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x104d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CTRL                                     = " "0, 1, 2, 3"
    tree.end
    tree "LBC_CHGR_VBAT_TRKL"
      sgroup "LBC_CHGR_VBAT_TRKL (at 0x1050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_VBAT_WEAK"
      sgroup "LBC_CHGR_VBAT_WEAK (at 0x1052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_IBAT_ATC_B"
      sgroup "LBC_CHGR_IBAT_ATC_B (at 0x1055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL                                      = " "0 (ICHG_ATC_B_450MA),1 (ICHG_ATC_B_990MA)"
    tree.end
    tree "LBC_CHGR_IBAT_TERM_CHGR"
      sgroup "LBC_CHGR_IBAT_TERM_CHGR (at 0x105b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80105b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x105b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COMP_EN                                  = " "0 (IBAT_TERM_COMP_DISABLED),1 (IBAT_TERM_COMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   THR_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "LBC_CHGR_TTRKL_MAX_EN"
      sgroup "LBC_CHGR_TTRKL_MAX_EN (at 0x105e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80105e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x105e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (TTRKL_MAX_DISABLED),1 (TTRKL_MAX_ENABLED)"
    tree.end
    tree "LBC_CHGR_TTRKL_MAX"
      sgroup "LBC_CHGR_TTRKL_MAX (at 0x105f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80105f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x105f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_TCHG_MAX_EN"
      sgroup "LBC_CHGR_TCHG_MAX_EN (at 0x1060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (TCHG_MAX_DISABLED),1 (TCHG_MAX_ENABLED)"
    tree.end
    tree "LBC_CHGR_TCHG_MAX"
      sgroup "LBC_CHGR_TCHG_MAX (at 0x1061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_CHG_WDOG_TIME"
      sgroup "LBC_CHGR_CHG_WDOG_TIME (at 0x1062)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "LBC_CHGR_CHG_WDOG_DLY"
      sgroup "LBC_CHGR_CHG_WDOG_DLY (at 0x1063)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SEL                                      = " "0 (CHG_WDOG_DLY_0SEC),1 (CHG_WDOG_DLY_1SEC),2 (CHG_WDOG_DLY_2SEC),3 (CHG_WDOG_DLY_3SEC),4 (CHG_WDOG_DLY_4SEC),5 (CHG_WDOG_DLY_5SEC),6 (CHG_WDOG_DLY_6SEC),7 (CHG_WDOG_DLY_7SEC)"
    tree.end
    tree "LBC_CHGR_CHG_WDOG_PET"
      sgroup "LBC_CHGR_CHG_WDOG_PET (at 0x1064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PET                                      = " "0, 1"
    tree.end
    tree "LBC_CHGR_CHG_WDOG_EN"
      sgroup "LBC_CHGR_CHG_WDOG_EN (at 0x1065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (CHG_WDOG_DISABLED),1 (CHG_WDOG_ENABLED)"
    tree.end
    tree "LBC_CHGR_CHG_TEMP_THRESH"
      sgroup "LBC_CHGR_CHG_TEMP_THRESH (at 0x1066)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHG_TEMP_STOP                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CHG_TEMP_RESUME                          = "
    tree.end
    tree "LBC_CHGR_VBAT_DET_EN"
      sgroup "LBC_CHGR_VBAT_DET_EN (at 0x1069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_DET_HI_LO_CTRL                      = " "0, 1, 2, 3"
    tree.end
    tree "LBC_CHGR_THERM_REG_START"
      sgroup "LBC_CHGR_THERM_REG_START (at 0x106a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80106a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x106a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   THERM_REG_START                          = " "0, 1, 2, 3"
    tree.end
    tree "LBC_CHGR_SEC_ACCESS"
      sgroup "LBC_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LBC_CHGR_PERPH_RESET_CTL2"
      sgroup "LBC_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_CHGR_PERPH_RESET_CTL3"
      sgroup "LBC_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LBC_CHGR_PERPH_RESET_CTL4"
      sgroup "LBC_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_CHGR_PERPH_RESET_CTL5"
      sgroup "LBC_CHGR_PERPH_RESET_CTL5 (at 0x10dc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010dc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10dc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_CHGR_PERPH_RESET_CTL6"
      sgroup "LBC_CHGR_PERPH_RESET_CTL6 (at 0x10dd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010dd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10dd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_CHGR_CHGR_SPARE"
      sgroup "LBC_CHGR_CHGR_SPARE (at 0x10df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "LBC_CHGR_INT_TEST1"
      sgroup "LBC_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LBC_CHGR_INT_TEST_VAL"
      sgroup "LBC_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_INT_VAL                      = " "0, 1"
    tree.end
    tree "LBC_CHGR_TRKL_CHG_TEST"
      sgroup "LBC_CHGR_TRKL_CHG_TEST (at 0x10e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_TRICKLE_FORCE                        = " "0 (NO_CHG_TRICKLE_FORCE),1 (CHG_TRICKLE_FORCED_ON)"
    tree.end
    tree "LBC_CHGR_TEST_LOOP"
      sgroup "LBC_CHGR_TEST_LOOP (at 0x10e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VIN_MIN_LOOP_DISABLE                     = " "0 (VCHG_LOOP_ENABLED),1 (VCHG_LOOP_DISABLED)"
    tree.end
    tree "LBC_CHGR_FSM_STATE_CAPTURE"
      sgroup "LBC_CHGR_FSM_STATE_CAPTURE (at 0x10e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_STATE_CAPTURE                        = " "0, 1"
    tree.end
    tree "LBC_CHGR_FSM_STATE_STS"
      sgroup "LBC_CHGR_FSM_STATE_STS (at 0x10e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FSM_STATE_STS                            = "
    tree.end
    tree "LBC_CHGR_FSM_STATE_TEST"
      sgroup "LBC_CHGR_FSM_STATE_TEST (at 0x10e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FSM_WRITE_STATE_DWELL                    = " "0 (FSM_FUNCTION_NORMALLY),1 (FSM_STAY_IN_WRITE_STATE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FSM_WRITE_STATE                          = "
    tree.end
    tree "LBC_CHGR_FSM_STATE_WRITE"
      sgroup "LBC_CHGR_FSM_STATE_WRITE (at 0x10e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0, 1"
    tree.end
    tree "LBC_CHGR_TIMER_SPEEDUP"
      sgroup "LBC_CHGR_TIMER_SPEEDUP (at 0x10ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TIMER_SPEED_UP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TIMER_RESET                              = " "0, 1"
    tree.end
    tree "LBC_CHGR_COMP_OVR0"
      sgroup "LBC_CHGR_COMP_OVR0 (at 0x10ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CHGR_VDD_LOOP_CMP                        = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VBAT_VERY_LOW                            = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHG_OPTION                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_CHGR_COMP_OVR1"
      sgroup "LBC_CHGR_COMP_OVR1 (at 0x10ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CHGR_VIN_LOOP_CMP                        = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VBAT_WEAK                                = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_DET_LO                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_CHGR_CHGR_COMP_OVR_GLOBAL"
      sgroup "LBC_CHGR_CHGR_COMP_OVR_GLOBAL (at 0x10ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
  tree.end
tree.end
tree "LBC_MISC"
  tree "LBC_MISC"
    tree "LBC_MISC_REVISION1"
      sgroup "LBC_MISC_REVISION1 (at 0x1600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LBC_MISC_REVISION2"
      sgroup "LBC_MISC_REVISION2 (at 0x1601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LBC_MISC_REVISION3"
      sgroup "LBC_MISC_REVISION3 (at 0x1602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LBC_MISC_REVISION4"
      sgroup "LBC_MISC_REVISION4 (at 0x1603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LBC_MISC_PERPH_TYPE"
      sgroup "LBC_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LBC_MISC_PERPH_SUBTYPE"
      sgroup "LBC_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LBC_MISC_LOW_POWER_MODE"
      sgroup "LBC_MISC_LOW_POWER_MODE (at 0x1640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (DIG_LPM_DISABLED),1 (DIG_LPM_ENABLED)"
    tree.end
    tree "LBC_MISC_BOOT"
      sgroup "LBC_MISC_BOOT (at 0x1641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOT_TIMER_EN                            = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADAPTIVE_BOOT_DIS                        = " "0 (ENABLED),1 (DISABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADAPTIVE_BOOT_TYPE                       = " "0 (INCREASE_VBAT_WEAK_100MV),1 (INCREASE_VBAT_WEAK_TO_3V4)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOT_TIMER                               = " "0 (T_30S),1 (T_60S),2 (T_90S),3 (T_120S)"
    tree.end
    tree "LBC_MISC_BOOT_DONE"
      sgroup "LBC_MISC_BOOT_DONE (at 0x1642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DONE                                     = " "0 (BOOT_NOT_DONE),1 (BOOT_DONE)"
    tree.end
    tree "LBC_MISC_VBAT_BOOT_THRES"
      sgroup "LBC_MISC_VBAT_BOOT_THRES (at 0x1643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STS                                      = "
    tree.end
    tree "LBC_MISC_CP_CTL"
      sgroup "LBC_MISC_CP_CTL (at 0x1649)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC_OSC_EN                                = " "0 (RC_OSC_DISABLED),1 (RC_OSC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CP_CLK_SRC                               = " "0 (CP_CLK_SRC_19P2MHZ_DIV_2),1 (CP_CLK_19P2MHZ_DIV_4),2 (CP_CLK_SRC_RCOSC),3 (reserved)"
    tree.end
    tree "LBC_MISC_RAW_XVDD_RB_SCRATCH"
      sgroup "LBC_MISC_RAW_XVDD_RB_SCRATCH (at 0x16cd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016cd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16cd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REG                                      = "
    tree.end
    tree "LBC_MISC_RAW_DVDD_RB_SCRATCH"
      sgroup "LBC_MISC_RAW_DVDD_RB_SCRATCH (at 0x16ce)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ce0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ce0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REG                                      = "
    tree.end
    tree "LBC_MISC_SEC_ACCESS"
      sgroup "LBC_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LBC_MISC_SMBB_MISC_SPARE"
      sgroup "LBC_MISC_SMBB_MISC_SPARE (at 0x16d7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL2"
      sgroup "LBC_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL3"
      sgroup "LBC_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL4"
      sgroup "LBC_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL5"
      sgroup "LBC_MISC_PERPH_RESET_CTL5 (at 0x16dc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016dc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16dc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL6"
      sgroup "LBC_MISC_PERPH_RESET_CTL6 (at 0x16dd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016dd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16dd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL7"
      sgroup "LBC_MISC_PERPH_RESET_CTL7 (at 0x16de)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016de0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16de0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_MISC_PERPH_RESET_CTL8"
      sgroup "LBC_MISC_PERPH_RESET_CTL8 (at 0x16df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_MISC_CLOCK_TEST_SLEEP"
      sgroup "LBC_MISC_CLOCK_TEST_SLEEP (at 0x16e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LPM_GLOBAL_TIMESCALE_EN                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_MODE                                 = " "0 (SLP_CLK_SWITCH_HW_CNTRLED),1 (SLP_CLK_SWITCH_SW_CNTRLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_19P2M                                = " "0 (CLK_19P2M_NOT_REQED),1 (CLK_19P2M_REQED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REQ_32K                                  = " "0 (CLK_32K_NOT_REQED),1 (CLK_32K_REQED)"
    tree.end
    tree "LBC_MISC_TEMP_TEST"
      sgroup "LBC_MISC_TEMP_TEST (at 0x16e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_4X_FET_DEB_CTL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TL_DIS_MODE                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEMP_TEST                                = "
    tree.end
    tree "LBC_MISC_DTEST_CTRL"
      sgroup "LBC_MISC_DTEST_CTRL (at 0x16e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "LBC_MISC_TEST_ATEST"
      sgroup "LBC_MISC_TEST_ATEST (at 0x16e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_SEL                                = "
    tree.end
    tree "LBC_MISC_COMP_OVR_GLOBAL"
      sgroup "LBC_MISC_COMP_OVR_GLOBAL (at 0x16ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "LBC_MISC_COMPARATOR_OVRIDE_1"
      sgroup "LBC_MISC_COMPARATOR_OVRIDE_1 (at 0x16eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ICHG_END_CMP_OVRD                        = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHGR_TEMP2HI_CMP_OVRD                    = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CMP_EN_4X_FET_OVRD                       = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHGR_ICHG_LOOP_CMP_OVRD                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_MISC_TRIM_NUM"
      sgroup "LBC_MISC_TRIM_NUM (at 0x16f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LBC_MISC_TRIM1"
      sgroup "LBC_MISC_TRIM1 (at 0x16f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FAST_CHG_CURR_1X                         = "
    tree.end
    tree "LBC_MISC_TRIM2"
      sgroup "LBC_MISC_TRIM2 (at 0x16f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FAST_CHG_CURR_4X                         = "
    tree.end
    tree "LBC_MISC_TRIM3"
      sgroup "LBC_MISC_TRIM3 (at 0x16f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TEMP_INITIAL                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATC_B_CURR_SEL                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRK_CHG_CURR                             = "
    tree.end
    tree "LBC_MISC_TRIM4"
      sgroup "LBC_MISC_TRIM4 (at 0x16f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST2_CHG_OK_CTL                         = " "0 (OTST2_DOESNT_ALLOW_FORCE_OFF_CHG_OK),1 (OTST2_ALLOW_FORCE_OFF_CHG_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TEMP_SLOPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RFU                                      = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BBG_REF                                  = "
    tree.end
  tree.end
tree.end
tree "LBC_USB"
  tree "LBC_USB"
    tree "LBC_USB_PERPH_TYPE"
      sgroup "LBC_USB_PERPH_TYPE (at 0x1304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LBC_USB_PERPH_SUBTYPE"
      sgroup "LBC_USB_PERPH_SUBTYPE (at 0x1305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LBC_USB_PWR_PTH_STS"
      sgroup "LBC_USB_PWR_PTH_STS (at 0x1308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   POWER_PATH                               = " "0 (NOT_USED),1 (POWERED_FROM_BATTERY),2 (POWERED_FROM_USB_CHARGER),3 (NOT_USED_3)"
    tree.end
    tree "LBC_USB_USB_CHG_PTH_STS"
      sgroup "LBC_USB_USB_CHG_PTH_STS (at 0x1309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   USB_VALID                                = " "0 (UNDER_VOLTAGE),1 (OVER_VOLTAGE),2 (IN_VALID_RANGE),3 (IN_VALID_RANGE_3)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENUM_TIMER_EXP                           = " "0 (ENUM_TIMER_HASNT_EXPIRED),1 (ENUM_TIMER_EXPIRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_COARSE_DET                           = " "0 (BELOW_COARSE_DET_THR),1 (ABOVE_COARSE_DET_THR)"
    tree.end
    tree "LBC_USB_INT_RT_STS"
      sgroup "LBC_USB_INT_RT_STS (at 0x1310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_RT_STS                    = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "LBC_USB_INT_SET_TYPE"
      sgroup "LBC_USB_INT_SET_TYPE (at 0x1311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LBC_USB_INT_POLARITY_HIGH"
      sgroup "LBC_USB_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_HIGH                            = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_HIGH                            = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_HIGH                         = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_HIGH                      = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_USB_INT_POLARITY_LOW"
      sgroup "LBC_USB_INT_POLARITY_LOW (at 0x1313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_LOW                             = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LOW                             = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LOW                          = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LOW                       = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "LBC_USB_INT_LATCHED_CLR"
      sgroup "LBC_USB_INT_LATCHED_CLR (at 0x1314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "LBC_USB_INT_EN_SET"
      sgroup "LBC_USB_INT_EN_SET (at 0x1315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_USB_INT_EN_CLR"
      sgroup "LBC_USB_INT_EN_CLR (at 0x1316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LBC_USB_INT_LATCHED_STS"
      sgroup "LBC_USB_INT_LATCHED_STS (at 0x1318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LBC_USB_INT_PENDING_STS"
      sgroup "LBC_USB_INT_PENDING_STS (at 0x1319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_STS                             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_STS                             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_STS                          = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_STS                       = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LBC_USB_INT_MID_SEL"
      sgroup "LBC_USB_INT_MID_SEL (at 0x131a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LBC_USB_INT_PRIORITY"
      sgroup "LBC_USB_INT_PRIORITY (at 0x131b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LBC_USB_USB_OVP_CTL"
      sgroup "LBC_USB_USB_OVP_CTL (at 0x1342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_VALID_DEB                            = " "0 (DEB_0MS),1 (DEB_5MS),2 (DEB_10MS),3 (DEB_20MS)"
    tree.end
    tree "LBC_USB_USB_SUSP"
      sgroup "LBC_USB_USB_SUSP (at 0x1347)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_SUSPEND                              = " "0 (USB_NOT_SUSPENDED),1 (USB_SUSPENDED)"
    tree.end
    tree "LBC_USB_ENUM_TIMER_STOP"
      sgroup "LBC_USB_ENUM_TIMER_STOP (at 0x134e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80134e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x134e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STOP                                     = " "0 (ENUM_TIMER_STOP),1 (ENUM_TIMER_RUN)"
    tree.end
    tree "LBC_USB_ENUM_TIMER"
      sgroup "LBC_USB_ENUM_TIMER (at 0x134f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80134f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x134f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL                                      = " "0 (ENUM_TIMER_30S),1 (ENUM_TIMER_60S),2 (ENUM_TIMER_90S),3 (ENUM_TIMER_120S)"
    tree.end
    tree "LBC_USB_SEC_ACCESS"
      sgroup "LBC_USB_SEC_ACCESS (at 0x13d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LBC_USB_PERPH_RESET_CTL2"
      sgroup "LBC_USB_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_USB_PERPH_RESET_CTL3"
      sgroup "LBC_USB_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LBC_USB_PERPH_RESET_CTL4"
      sgroup "LBC_USB_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_USB_PERPH_RESET_CTL5"
      sgroup "LBC_USB_PERPH_RESET_CTL5 (at 0x13dc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013dc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13dc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LBC_USB_PERPH_RESET_CTL6"
      sgroup "LBC_USB_PERPH_RESET_CTL6 (at 0x13dd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013dd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13dd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LBC_USB_USB_SPARE"
      sgroup "LBC_USB_USB_SPARE (at 0x13df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "LBC_USB_INT_TEST1"
      sgroup "LBC_USB_INT_TEST1 (at 0x13e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LBC_USB_INT_TEST_VAL"
      sgroup "LBC_USB_INT_TEST_VAL (at 0x13e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERTEMP_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_INT_VAL                   = " "0, 1"
    tree.end
    tree "LBC_USB_USB_OVP_TST0"
      sgroup "LBC_USB_USB_OVP_TST0 (at 0x13e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST1_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "LBC_USB_USB_OVP_TST1"
      sgroup "LBC_USB_USB_OVP_TST1 (at 0x13e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OVP_DTEST2_OUT_SEL_USB                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST3_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "LBC_USB_USB_OVP_TST2"
      sgroup "LBC_USB_USB_OVP_TST2 (at 0x13e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USBIN_LLIMIT_FALLHYS                     = " "0 (T_HYS_0US),1 (T_HYS_1US),2 (T_HYS_2US),3 (T_HYS_3US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST4_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "LBC_USB_USB_OVP_TST5"
      sgroup "LBC_USB_USB_OVP_TST5 (at 0x13e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_CHG_OK_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USBIN_ULIMIT_FALLHYS                     = " "0 (T_HYS_400NS),1 (T_HYS_600NS),2 (T_HYS_800NS),3 (T_HYS_1US)"
    tree.end
    tree "LBC_USB_COMP_OVR0"
      sgroup "LBC_USB_COMP_OVR0 (at 0x13e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   COARSE_DET_USBIN                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_USB_COMP_OVR1"
      sgroup "LBC_USB_COMP_OVR1 (at 0x13ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHG_GONE                                 = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USBIN_ULIMIT_OK                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USBIN_LLIMIT_OK                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LBC_USB_USB_COMP_OVR_GLOBAL"
      sgroup "LBC_USB_USB_COMP_OVR_GLOBAL (at 0x13eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "LBC_USB_ENUM_TIMER_EN"
      sgroup "LBC_USB_ENUM_TIMER_EN (at 0x13ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DISABLED),1 (ENABLED)"
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      sgroup "LDO1_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      sgroup "LDO1_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      sgroup "LDO1_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      sgroup "LDO1_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      sgroup "LDO1_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      sgroup "LDO1_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      sgroup "LDO1_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO1_STATUS2"
      sgroup "LDO1_STATUS2 (at 0x14009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO1_INT_RT_STS"
      sgroup "LDO1_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      sgroup "LDO1_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      sgroup "LDO1_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      sgroup "LDO1_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      sgroup "LDO1_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      sgroup "LDO1_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      sgroup "LDO1_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      sgroup "LDO1_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      sgroup "LDO1_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      sgroup "LDO1_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      sgroup "LDO1_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      sgroup "LDO1_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      sgroup "LDO1_MODE_CTL2 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      sgroup "LDO1_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      sgroup "LDO1_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      sgroup "LDO1_SOFT_START_CTL (at 0x1404c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      sgroup "LDO1_CONFIG_CTL (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO1_VS_CTL"
      sgroup "LDO1_VS_CTL (at 0x14061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO1_SEC_ACCESS"
      sgroup "LDO1_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      sgroup "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      sgroup "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      sgroup "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      sgroup "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      sgroup "LDO1_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      sgroup "LDO1_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      sgroup "LDO1_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      sgroup "LDO1_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO1_TRIM_NUM"
      sgroup "LDO1_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      sgroup "LDO1_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      sgroup "LDO10_REVISION1 (at 0x14900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      sgroup "LDO10_REVISION2 (at 0x14901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      sgroup "LDO10_REVISION3 (at 0x14902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      sgroup "LDO10_REVISION4 (at 0x14903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      sgroup "LDO10_PERPH_TYPE (at 0x14904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      sgroup "LDO10_PERPH_SUBTYPE (at 0x14905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      sgroup "LDO10_STATUS1 (at 0x14908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO10_STATUS2"
      sgroup "LDO10_STATUS2 (at 0x14909)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO10_INT_RT_STS"
      sgroup "LDO10_INT_RT_STS (at 0x14910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      sgroup "LDO10_INT_SET_TYPE (at 0x14911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      sgroup "LDO10_INT_POLARITY_HIGH (at 0x14912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      sgroup "LDO10_INT_POLARITY_LOW (at 0x14913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      sgroup "LDO10_INT_LATCHED_CLR (at 0x14914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO10_INT_EN_SET"
      sgroup "LDO10_INT_EN_SET (at 0x14915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_EN_CLR"
      sgroup "LDO10_INT_EN_CLR (at 0x14916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      sgroup "LDO10_INT_LATCHED_STS (at 0x14918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      sgroup "LDO10_INT_PENDING_STS (at 0x14919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_MID_SEL"
      sgroup "LDO10_INT_MID_SEL (at 0x1491a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO10_INT_PRIORITY"
      sgroup "LDO10_INT_PRIORITY (at 0x1491b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO10_VOLTAGE_CTL2"
      sgroup "LDO10_VOLTAGE_CTL2 (at 0x14941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO10_MODE_CTL2"
      sgroup "LDO10_MODE_CTL2 (at 0x14945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO10_EN_CTL"
      sgroup "LDO10_EN_CTL (at 0x14946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO10_PD_CTL"
      sgroup "LDO10_PD_CTL (at 0x14948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO10_SOFT_START_CTL"
      sgroup "LDO10_SOFT_START_CTL (at 0x1494c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80494c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x494c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO10_CONFIG_CTL"
      sgroup "LDO10_CONFIG_CTL (at 0x14952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO10_SEC_ACCESS"
      sgroup "LDO10_SEC_ACCESS (at 0x149d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      sgroup "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      sgroup "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      sgroup "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      sgroup "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO10_INT_TEST1"
      sgroup "LDO10_INT_TEST1 (at 0x149e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      sgroup "LDO10_INT_TEST_VAL (at 0x149e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO10_TEST1"
      sgroup "LDO10_TEST1 (at 0x149e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      sgroup "LDO10_TEST2 (at 0x149e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO10_TRIM_NUM"
      sgroup "LDO10_TRIM_NUM (at 0x149f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      sgroup "LDO10_TRIM_CTRL (at 0x149f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      sgroup "LDO11_REVISION1 (at 0x14a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      sgroup "LDO11_REVISION2 (at 0x14a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      sgroup "LDO11_REVISION3 (at 0x14a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      sgroup "LDO11_REVISION4 (at 0x14a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      sgroup "LDO11_PERPH_TYPE (at 0x14a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      sgroup "LDO11_PERPH_SUBTYPE (at 0x14a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      sgroup "LDO11_STATUS1 (at 0x14a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO11_STATUS2"
      sgroup "LDO11_STATUS2 (at 0x14a09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO11_INT_RT_STS"
      sgroup "LDO11_INT_RT_STS (at 0x14a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_SET_TYPE"
      sgroup "LDO11_INT_SET_TYPE (at 0x14a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_HIGH"
      sgroup "LDO11_INT_POLARITY_HIGH (at 0x14a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_LOW"
      sgroup "LDO11_INT_POLARITY_LOW (at 0x14a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO11_INT_LATCHED_CLR"
      sgroup "LDO11_INT_LATCHED_CLR (at 0x14a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO11_INT_EN_SET"
      sgroup "LDO11_INT_EN_SET (at 0x14a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_EN_CLR"
      sgroup "LDO11_INT_EN_CLR (at 0x14a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_LATCHED_STS"
      sgroup "LDO11_INT_LATCHED_STS (at 0x14a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO11_INT_PENDING_STS"
      sgroup "LDO11_INT_PENDING_STS (at 0x14a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_MID_SEL"
      sgroup "LDO11_INT_MID_SEL (at 0x14a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO11_INT_PRIORITY"
      sgroup "LDO11_INT_PRIORITY (at 0x14a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO11_VOLTAGE_CTL2"
      sgroup "LDO11_VOLTAGE_CTL2 (at 0x14a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO11_MODE_CTL2"
      sgroup "LDO11_MODE_CTL2 (at 0x14a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO11_EN_CTL"
      sgroup "LDO11_EN_CTL (at 0x14a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO11_PD_CTL"
      sgroup "LDO11_PD_CTL (at 0x14a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO11_SOFT_START_CTL"
      sgroup "LDO11_SOFT_START_CTL (at 0x14a4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO11_CONFIG_CTL"
      sgroup "LDO11_CONFIG_CTL (at 0x14a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO11_SEC_ACCESS"
      sgroup "LDO11_SEC_ACCESS (at 0x14ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      sgroup "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      sgroup "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      sgroup "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      sgroup "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO11_INT_TEST1"
      sgroup "LDO11_INT_TEST1 (at 0x14ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO11_INT_TEST_VAL"
      sgroup "LDO11_INT_TEST_VAL (at 0x14ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO11_TEST1"
      sgroup "LDO11_TEST1 (at 0x14ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO11_TEST2"
      sgroup "LDO11_TEST2 (at 0x14ae3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO11_TRIM_NUM"
      sgroup "LDO11_TRIM_NUM (at 0x14af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO11_TRIM_CTRL"
      sgroup "LDO11_TRIM_CTRL (at 0x14af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      sgroup "LDO12_REVISION1 (at 0x14b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      sgroup "LDO12_REVISION2 (at 0x14b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      sgroup "LDO12_REVISION3 (at 0x14b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      sgroup "LDO12_REVISION4 (at 0x14b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      sgroup "LDO12_PERPH_TYPE (at 0x14b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      sgroup "LDO12_PERPH_SUBTYPE (at 0x14b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      sgroup "LDO12_STATUS1 (at 0x14b08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO12_STATUS2"
      sgroup "LDO12_STATUS2 (at 0x14b09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO12_INT_RT_STS"
      sgroup "LDO12_INT_RT_STS (at 0x14b10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      sgroup "LDO12_INT_SET_TYPE (at 0x14b11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      sgroup "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      sgroup "LDO12_INT_POLARITY_LOW (at 0x14b13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      sgroup "LDO12_INT_LATCHED_CLR (at 0x14b14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO12_INT_EN_SET"
      sgroup "LDO12_INT_EN_SET (at 0x14b15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_EN_CLR"
      sgroup "LDO12_INT_EN_CLR (at 0x14b16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      sgroup "LDO12_INT_LATCHED_STS (at 0x14b18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      sgroup "LDO12_INT_PENDING_STS (at 0x14b19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_MID_SEL"
      sgroup "LDO12_INT_MID_SEL (at 0x14b1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO12_INT_PRIORITY"
      sgroup "LDO12_INT_PRIORITY (at 0x14b1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO12_VOLTAGE_CTL2"
      sgroup "LDO12_VOLTAGE_CTL2 (at 0x14b41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO12_MODE_CTL2"
      sgroup "LDO12_MODE_CTL2 (at 0x14b45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO12_EN_CTL"
      sgroup "LDO12_EN_CTL (at 0x14b46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO12_PD_CTL"
      sgroup "LDO12_PD_CTL (at 0x14b48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO12_SOFT_START_CTL"
      sgroup "LDO12_SOFT_START_CTL (at 0x14b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO12_CONFIG_CTL"
      sgroup "LDO12_CONFIG_CTL (at 0x14b52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO12_SEC_ACCESS"
      sgroup "LDO12_SEC_ACCESS (at 0x14bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      sgroup "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      sgroup "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      sgroup "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      sgroup "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO12_INT_TEST1"
      sgroup "LDO12_INT_TEST1 (at 0x14be0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      sgroup "LDO12_INT_TEST_VAL (at 0x14be1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO12_TEST1"
      sgroup "LDO12_TEST1 (at 0x14be2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      sgroup "LDO12_TEST2 (at 0x14be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO12_TRIM_NUM"
      sgroup "LDO12_TRIM_NUM (at 0x14bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      sgroup "LDO12_TRIM_CTRL (at 0x14bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      sgroup "LDO13_REVISION1 (at 0x14c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      sgroup "LDO13_REVISION2 (at 0x14c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      sgroup "LDO13_REVISION3 (at 0x14c02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      sgroup "LDO13_REVISION4 (at 0x14c03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      sgroup "LDO13_PERPH_TYPE (at 0x14c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      sgroup "LDO13_PERPH_SUBTYPE (at 0x14c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      sgroup "LDO13_STATUS1 (at 0x14c08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO13_STATUS2"
      sgroup "LDO13_STATUS2 (at 0x14c09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO13_INT_RT_STS"
      sgroup "LDO13_INT_RT_STS (at 0x14c10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_SET_TYPE"
      sgroup "LDO13_INT_SET_TYPE (at 0x14c11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_HIGH"
      sgroup "LDO13_INT_POLARITY_HIGH (at 0x14c12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_LOW"
      sgroup "LDO13_INT_POLARITY_LOW (at 0x14c13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO13_INT_LATCHED_CLR"
      sgroup "LDO13_INT_LATCHED_CLR (at 0x14c14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO13_INT_EN_SET"
      sgroup "LDO13_INT_EN_SET (at 0x14c15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_EN_CLR"
      sgroup "LDO13_INT_EN_CLR (at 0x14c16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_LATCHED_STS"
      sgroup "LDO13_INT_LATCHED_STS (at 0x14c18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO13_INT_PENDING_STS"
      sgroup "LDO13_INT_PENDING_STS (at 0x14c19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_MID_SEL"
      sgroup "LDO13_INT_MID_SEL (at 0x14c1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO13_INT_PRIORITY"
      sgroup "LDO13_INT_PRIORITY (at 0x14c1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO13_VOLTAGE_CTL2"
      sgroup "LDO13_VOLTAGE_CTL2 (at 0x14c41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO13_MODE_CTL2"
      sgroup "LDO13_MODE_CTL2 (at 0x14c45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO13_EN_CTL"
      sgroup "LDO13_EN_CTL (at 0x14c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO13_PD_CTL"
      sgroup "LDO13_PD_CTL (at 0x14c48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO13_SOFT_START_CTL"
      sgroup "LDO13_SOFT_START_CTL (at 0x14c4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO13_CONFIG_CTL"
      sgroup "LDO13_CONFIG_CTL (at 0x14c52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO13_SEC_ACCESS"
      sgroup "LDO13_SEC_ACCESS (at 0x14cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      sgroup "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      sgroup "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      sgroup "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      sgroup "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO13_INT_TEST1"
      sgroup "LDO13_INT_TEST1 (at 0x14ce0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO13_INT_TEST_VAL"
      sgroup "LDO13_INT_TEST_VAL (at 0x14ce1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO13_TEST1"
      sgroup "LDO13_TEST1 (at 0x14ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO13_TEST2"
      sgroup "LDO13_TEST2 (at 0x14ce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO13_TRIM_NUM"
      sgroup "LDO13_TRIM_NUM (at 0x14cf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO13_TRIM_CTRL"
      sgroup "LDO13_TRIM_CTRL (at 0x14cf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO14"
  tree "LDO14"
    tree "LDO14_REVISION1"
      sgroup "LDO14_REVISION1 (at 0x14d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO14_REVISION2"
      sgroup "LDO14_REVISION2 (at 0x14d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO14_REVISION3"
      sgroup "LDO14_REVISION3 (at 0x14d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO14_REVISION4"
      sgroup "LDO14_REVISION4 (at 0x14d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO14_PERPH_TYPE"
      sgroup "LDO14_PERPH_TYPE (at 0x14d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO14_PERPH_SUBTYPE"
      sgroup "LDO14_PERPH_SUBTYPE (at 0x14d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO14_STATUS1"
      sgroup "LDO14_STATUS1 (at 0x14d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO14_STATUS2"
      sgroup "LDO14_STATUS2 (at 0x14d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO14_INT_RT_STS"
      sgroup "LDO14_INT_RT_STS (at 0x14d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_SET_TYPE"
      sgroup "LDO14_INT_SET_TYPE (at 0x14d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_HIGH"
      sgroup "LDO14_INT_POLARITY_HIGH (at 0x14d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_LOW"
      sgroup "LDO14_INT_POLARITY_LOW (at 0x14d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO14_INT_LATCHED_CLR"
      sgroup "LDO14_INT_LATCHED_CLR (at 0x14d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO14_INT_EN_SET"
      sgroup "LDO14_INT_EN_SET (at 0x14d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_EN_CLR"
      sgroup "LDO14_INT_EN_CLR (at 0x14d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_LATCHED_STS"
      sgroup "LDO14_INT_LATCHED_STS (at 0x14d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO14_INT_PENDING_STS"
      sgroup "LDO14_INT_PENDING_STS (at 0x14d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_MID_SEL"
      sgroup "LDO14_INT_MID_SEL (at 0x14d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO14_INT_PRIORITY"
      sgroup "LDO14_INT_PRIORITY (at 0x14d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO14_VOLTAGE_CTL2"
      sgroup "LDO14_VOLTAGE_CTL2 (at 0x14d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO14_MODE_CTL2"
      sgroup "LDO14_MODE_CTL2 (at 0x14d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO14_EN_CTL"
      sgroup "LDO14_EN_CTL (at 0x14d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO14_PD_CTL"
      sgroup "LDO14_PD_CTL (at 0x14d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO14_SOFT_START_CTL"
      sgroup "LDO14_SOFT_START_CTL (at 0x14d4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO14_CONFIG_CTL"
      sgroup "LDO14_CONFIG_CTL (at 0x14d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO14_SEC_ACCESS"
      sgroup "LDO14_SEC_ACCESS (at 0x14dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO14_PERPH_RESET_CTL1"
      sgroup "LDO14_PERPH_RESET_CTL1 (at 0x14dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL2"
      sgroup "LDO14_PERPH_RESET_CTL2 (at 0x14dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL3"
      sgroup "LDO14_PERPH_RESET_CTL3 (at 0x14dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL4"
      sgroup "LDO14_PERPH_RESET_CTL4 (at 0x14ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO14_INT_TEST1"
      sgroup "LDO14_INT_TEST1 (at 0x14de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO14_INT_TEST_VAL"
      sgroup "LDO14_INT_TEST_VAL (at 0x14de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO14_TEST1"
      sgroup "LDO14_TEST1 (at 0x14de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO14_TEST2"
      sgroup "LDO14_TEST2 (at 0x14de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO14_TRIM_NUM"
      sgroup "LDO14_TRIM_NUM (at 0x14df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO14_TRIM_CTRL"
      sgroup "LDO14_TRIM_CTRL (at 0x14df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO15"
  tree "LDO15"
    tree "LDO15_REVISION1"
      sgroup "LDO15_REVISION1 (at 0x14e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO15_REVISION2"
      sgroup "LDO15_REVISION2 (at 0x14e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO15_REVISION3"
      sgroup "LDO15_REVISION3 (at 0x14e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO15_REVISION4"
      sgroup "LDO15_REVISION4 (at 0x14e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO15_PERPH_TYPE"
      sgroup "LDO15_PERPH_TYPE (at 0x14e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO15_PERPH_SUBTYPE"
      sgroup "LDO15_PERPH_SUBTYPE (at 0x14e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO15_STATUS1"
      sgroup "LDO15_STATUS1 (at 0x14e08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO15_STATUS2"
      sgroup "LDO15_STATUS2 (at 0x14e09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO15_INT_RT_STS"
      sgroup "LDO15_INT_RT_STS (at 0x14e10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_SET_TYPE"
      sgroup "LDO15_INT_SET_TYPE (at 0x14e11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_HIGH"
      sgroup "LDO15_INT_POLARITY_HIGH (at 0x14e12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_LOW"
      sgroup "LDO15_INT_POLARITY_LOW (at 0x14e13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO15_INT_LATCHED_CLR"
      sgroup "LDO15_INT_LATCHED_CLR (at 0x14e14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO15_INT_EN_SET"
      sgroup "LDO15_INT_EN_SET (at 0x14e15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_EN_CLR"
      sgroup "LDO15_INT_EN_CLR (at 0x14e16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_LATCHED_STS"
      sgroup "LDO15_INT_LATCHED_STS (at 0x14e18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO15_INT_PENDING_STS"
      sgroup "LDO15_INT_PENDING_STS (at 0x14e19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_MID_SEL"
      sgroup "LDO15_INT_MID_SEL (at 0x14e1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO15_INT_PRIORITY"
      sgroup "LDO15_INT_PRIORITY (at 0x14e1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO15_VOLTAGE_CTL2"
      sgroup "LDO15_VOLTAGE_CTL2 (at 0x14e41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO15_MODE_CTL2"
      sgroup "LDO15_MODE_CTL2 (at 0x14e45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO15_EN_CTL"
      sgroup "LDO15_EN_CTL (at 0x14e46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO15_PD_CTL"
      sgroup "LDO15_PD_CTL (at 0x14e48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO15_SOFT_START_CTL"
      sgroup "LDO15_SOFT_START_CTL (at 0x14e4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO15_CONFIG_CTL"
      sgroup "LDO15_CONFIG_CTL (at 0x14e52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO15_SEC_ACCESS"
      sgroup "LDO15_SEC_ACCESS (at 0x14ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO15_PERPH_RESET_CTL1"
      sgroup "LDO15_PERPH_RESET_CTL1 (at 0x14ed8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL2"
      sgroup "LDO15_PERPH_RESET_CTL2 (at 0x14ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL3"
      sgroup "LDO15_PERPH_RESET_CTL3 (at 0x14eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL4"
      sgroup "LDO15_PERPH_RESET_CTL4 (at 0x14edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO15_INT_TEST1"
      sgroup "LDO15_INT_TEST1 (at 0x14ee0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO15_INT_TEST_VAL"
      sgroup "LDO15_INT_TEST_VAL (at 0x14ee1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO15_TEST1"
      sgroup "LDO15_TEST1 (at 0x14ee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO15_TEST2"
      sgroup "LDO15_TEST2 (at 0x14ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO15_TRIM_NUM"
      sgroup "LDO15_TRIM_NUM (at 0x14ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO15_TRIM_CTRL"
      sgroup "LDO15_TRIM_CTRL (at 0x14ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO16"
  tree "LDO16"
    tree "LDO16_REVISION1"
      sgroup "LDO16_REVISION1 (at 0x14f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO16_REVISION2"
      sgroup "LDO16_REVISION2 (at 0x14f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO16_REVISION3"
      sgroup "LDO16_REVISION3 (at 0x14f02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO16_REVISION4"
      sgroup "LDO16_REVISION4 (at 0x14f03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO16_PERPH_TYPE"
      sgroup "LDO16_PERPH_TYPE (at 0x14f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO16_PERPH_SUBTYPE"
      sgroup "LDO16_PERPH_SUBTYPE (at 0x14f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO16_STATUS1"
      sgroup "LDO16_STATUS1 (at 0x14f08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO16_STATUS2"
      sgroup "LDO16_STATUS2 (at 0x14f09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO16_INT_RT_STS"
      sgroup "LDO16_INT_RT_STS (at 0x14f10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_SET_TYPE"
      sgroup "LDO16_INT_SET_TYPE (at 0x14f11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_HIGH"
      sgroup "LDO16_INT_POLARITY_HIGH (at 0x14f12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_LOW"
      sgroup "LDO16_INT_POLARITY_LOW (at 0x14f13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO16_INT_LATCHED_CLR"
      sgroup "LDO16_INT_LATCHED_CLR (at 0x14f14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO16_INT_EN_SET"
      sgroup "LDO16_INT_EN_SET (at 0x14f15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_EN_CLR"
      sgroup "LDO16_INT_EN_CLR (at 0x14f16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_LATCHED_STS"
      sgroup "LDO16_INT_LATCHED_STS (at 0x14f18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO16_INT_PENDING_STS"
      sgroup "LDO16_INT_PENDING_STS (at 0x14f19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_MID_SEL"
      sgroup "LDO16_INT_MID_SEL (at 0x14f1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO16_INT_PRIORITY"
      sgroup "LDO16_INT_PRIORITY (at 0x14f1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO16_VOLTAGE_CTL2"
      sgroup "LDO16_VOLTAGE_CTL2 (at 0x14f41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO16_MODE_CTL2"
      sgroup "LDO16_MODE_CTL2 (at 0x14f45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO16_EN_CTL"
      sgroup "LDO16_EN_CTL (at 0x14f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO16_PD_CTL"
      sgroup "LDO16_PD_CTL (at 0x14f48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO16_SOFT_START_CTL"
      sgroup "LDO16_SOFT_START_CTL (at 0x14f4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO16_CONFIG_CTL"
      sgroup "LDO16_CONFIG_CTL (at 0x14f52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO16_SEC_ACCESS"
      sgroup "LDO16_SEC_ACCESS (at 0x14fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO16_PERPH_RESET_CTL1"
      sgroup "LDO16_PERPH_RESET_CTL1 (at 0x14fd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL2"
      sgroup "LDO16_PERPH_RESET_CTL2 (at 0x14fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL3"
      sgroup "LDO16_PERPH_RESET_CTL3 (at 0x14fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL4"
      sgroup "LDO16_PERPH_RESET_CTL4 (at 0x14fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO16_INT_TEST1"
      sgroup "LDO16_INT_TEST1 (at 0x14fe0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO16_INT_TEST_VAL"
      sgroup "LDO16_INT_TEST_VAL (at 0x14fe1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO16_TEST1"
      sgroup "LDO16_TEST1 (at 0x14fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO16_TEST2"
      sgroup "LDO16_TEST2 (at 0x14fe3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO16_TRIM_NUM"
      sgroup "LDO16_TRIM_NUM (at 0x14ff0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO16_TRIM_CTRL"
      sgroup "LDO16_TRIM_CTRL (at 0x14ff1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO17"
  tree "LDO17"
    tree "LDO17_REVISION1"
      sgroup "LDO17_REVISION1 (at 0x15000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO17_REVISION2"
      sgroup "LDO17_REVISION2 (at 0x15001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO17_REVISION3"
      sgroup "LDO17_REVISION3 (at 0x15002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO17_REVISION4"
      sgroup "LDO17_REVISION4 (at 0x15003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO17_PERPH_TYPE"
      sgroup "LDO17_PERPH_TYPE (at 0x15004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO17_PERPH_SUBTYPE"
      sgroup "LDO17_PERPH_SUBTYPE (at 0x15005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO17_STATUS1"
      sgroup "LDO17_STATUS1 (at 0x15008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO17_STATUS2"
      sgroup "LDO17_STATUS2 (at 0x15009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO17_INT_RT_STS"
      sgroup "LDO17_INT_RT_STS (at 0x15010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO17_INT_SET_TYPE"
      sgroup "LDO17_INT_SET_TYPE (at 0x15011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO17_INT_POLARITY_HIGH"
      sgroup "LDO17_INT_POLARITY_HIGH (at 0x15012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO17_INT_POLARITY_LOW"
      sgroup "LDO17_INT_POLARITY_LOW (at 0x15013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO17_INT_LATCHED_CLR"
      sgroup "LDO17_INT_LATCHED_CLR (at 0x15014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO17_INT_EN_SET"
      sgroup "LDO17_INT_EN_SET (at 0x15015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO17_INT_EN_CLR"
      sgroup "LDO17_INT_EN_CLR (at 0x15016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO17_INT_LATCHED_STS"
      sgroup "LDO17_INT_LATCHED_STS (at 0x15018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO17_INT_PENDING_STS"
      sgroup "LDO17_INT_PENDING_STS (at 0x15019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO17_INT_MID_SEL"
      sgroup "LDO17_INT_MID_SEL (at 0x1501a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80501a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x501a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO17_INT_PRIORITY"
      sgroup "LDO17_INT_PRIORITY (at 0x1501b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80501b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x501b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO17_VOLTAGE_CTL2"
      sgroup "LDO17_VOLTAGE_CTL2 (at 0x15041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO17_MODE_CTL2"
      sgroup "LDO17_MODE_CTL2 (at 0x15045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO17_EN_CTL"
      sgroup "LDO17_EN_CTL (at 0x15046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO17_PD_CTL"
      sgroup "LDO17_PD_CTL (at 0x15048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO17_SOFT_START_CTL"
      sgroup "LDO17_SOFT_START_CTL (at 0x1504c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO17_CONFIG_CTL"
      sgroup "LDO17_CONFIG_CTL (at 0x15052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO17_SEC_ACCESS"
      sgroup "LDO17_SEC_ACCESS (at 0x150d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO17_PERPH_RESET_CTL1"
      sgroup "LDO17_PERPH_RESET_CTL1 (at 0x150d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL2"
      sgroup "LDO17_PERPH_RESET_CTL2 (at 0x150d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL3"
      sgroup "LDO17_PERPH_RESET_CTL3 (at 0x150da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL4"
      sgroup "LDO17_PERPH_RESET_CTL4 (at 0x150db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO17_INT_TEST1"
      sgroup "LDO17_INT_TEST1 (at 0x150e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO17_INT_TEST_VAL"
      sgroup "LDO17_INT_TEST_VAL (at 0x150e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO17_TEST1"
      sgroup "LDO17_TEST1 (at 0x150e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO17_TEST2"
      sgroup "LDO17_TEST2 (at 0x150e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO17_TRIM_NUM"
      sgroup "LDO17_TRIM_NUM (at 0x150f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO17_TRIM_CTRL"
      sgroup "LDO17_TRIM_CTRL (at 0x150f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO18"
  tree "LDO18"
    tree "LDO18_REVISION1"
      sgroup "LDO18_REVISION1 (at 0x15100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO18_REVISION2"
      sgroup "LDO18_REVISION2 (at 0x15101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO18_REVISION3"
      sgroup "LDO18_REVISION3 (at 0x15102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO18_REVISION4"
      sgroup "LDO18_REVISION4 (at 0x15103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO18_PERPH_TYPE"
      sgroup "LDO18_PERPH_TYPE (at 0x15104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO18_PERPH_SUBTYPE"
      sgroup "LDO18_PERPH_SUBTYPE (at 0x15105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO18_STATUS1"
      sgroup "LDO18_STATUS1 (at 0x15108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO18_STATUS2"
      sgroup "LDO18_STATUS2 (at 0x15109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO18_INT_RT_STS"
      sgroup "LDO18_INT_RT_STS (at 0x15110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO18_INT_SET_TYPE"
      sgroup "LDO18_INT_SET_TYPE (at 0x15111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO18_INT_POLARITY_HIGH"
      sgroup "LDO18_INT_POLARITY_HIGH (at 0x15112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO18_INT_POLARITY_LOW"
      sgroup "LDO18_INT_POLARITY_LOW (at 0x15113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO18_INT_LATCHED_CLR"
      sgroup "LDO18_INT_LATCHED_CLR (at 0x15114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO18_INT_EN_SET"
      sgroup "LDO18_INT_EN_SET (at 0x15115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO18_INT_EN_CLR"
      sgroup "LDO18_INT_EN_CLR (at 0x15116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO18_INT_LATCHED_STS"
      sgroup "LDO18_INT_LATCHED_STS (at 0x15118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO18_INT_PENDING_STS"
      sgroup "LDO18_INT_PENDING_STS (at 0x15119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO18_INT_MID_SEL"
      sgroup "LDO18_INT_MID_SEL (at 0x1511a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80511a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x511a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO18_INT_PRIORITY"
      sgroup "LDO18_INT_PRIORITY (at 0x1511b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80511b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x511b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO18_VOLTAGE_CTL2"
      sgroup "LDO18_VOLTAGE_CTL2 (at 0x15141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO18_MODE_CTL2"
      sgroup "LDO18_MODE_CTL2 (at 0x15145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO18_EN_CTL"
      sgroup "LDO18_EN_CTL (at 0x15146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO18_PD_CTL"
      sgroup "LDO18_PD_CTL (at 0x15148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO18_SOFT_START_CTL"
      sgroup "LDO18_SOFT_START_CTL (at 0x1514c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80514c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x514c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO18_CONFIG_CTL"
      sgroup "LDO18_CONFIG_CTL (at 0x15152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO18_SEC_ACCESS"
      sgroup "LDO18_SEC_ACCESS (at 0x151d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO18_PERPH_RESET_CTL1"
      sgroup "LDO18_PERPH_RESET_CTL1 (at 0x151d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL2"
      sgroup "LDO18_PERPH_RESET_CTL2 (at 0x151d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL3"
      sgroup "LDO18_PERPH_RESET_CTL3 (at 0x151da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL4"
      sgroup "LDO18_PERPH_RESET_CTL4 (at 0x151db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO18_INT_TEST1"
      sgroup "LDO18_INT_TEST1 (at 0x151e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO18_INT_TEST_VAL"
      sgroup "LDO18_INT_TEST_VAL (at 0x151e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO18_TEST1"
      sgroup "LDO18_TEST1 (at 0x151e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO18_TEST2"
      sgroup "LDO18_TEST2 (at 0x151e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO18_TRIM_NUM"
      sgroup "LDO18_TRIM_NUM (at 0x151f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO18_TRIM_CTRL"
      sgroup "LDO18_TRIM_CTRL (at 0x151f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO2"
  tree "LDO2"
    tree "LDO2_REVISION1"
      sgroup "LDO2_REVISION1 (at 0x14100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO2_REVISION2"
      sgroup "LDO2_REVISION2 (at 0x14101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO2_REVISION3"
      sgroup "LDO2_REVISION3 (at 0x14102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO2_REVISION4"
      sgroup "LDO2_REVISION4 (at 0x14103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO2_PERPH_TYPE"
      sgroup "LDO2_PERPH_TYPE (at 0x14104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO2_PERPH_SUBTYPE"
      sgroup "LDO2_PERPH_SUBTYPE (at 0x14105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO2_STATUS1"
      sgroup "LDO2_STATUS1 (at 0x14108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO2_STATUS2"
      sgroup "LDO2_STATUS2 (at 0x14109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO2_INT_RT_STS"
      sgroup "LDO2_INT_RT_STS (at 0x14110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_SET_TYPE"
      sgroup "LDO2_INT_SET_TYPE (at 0x14111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_HIGH"
      sgroup "LDO2_INT_POLARITY_HIGH (at 0x14112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_LOW"
      sgroup "LDO2_INT_POLARITY_LOW (at 0x14113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO2_INT_LATCHED_CLR"
      sgroup "LDO2_INT_LATCHED_CLR (at 0x14114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO2_INT_EN_SET"
      sgroup "LDO2_INT_EN_SET (at 0x14115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_EN_CLR"
      sgroup "LDO2_INT_EN_CLR (at 0x14116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_LATCHED_STS"
      sgroup "LDO2_INT_LATCHED_STS (at 0x14118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO2_INT_PENDING_STS"
      sgroup "LDO2_INT_PENDING_STS (at 0x14119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_MID_SEL"
      sgroup "LDO2_INT_MID_SEL (at 0x1411a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO2_INT_PRIORITY"
      sgroup "LDO2_INT_PRIORITY (at 0x1411b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO2_VOLTAGE_CTL2"
      sgroup "LDO2_VOLTAGE_CTL2 (at 0x14141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO2_MODE_CTL2"
      sgroup "LDO2_MODE_CTL2 (at 0x14145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO2_EN_CTL"
      sgroup "LDO2_EN_CTL (at 0x14146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO2_PD_CTL"
      sgroup "LDO2_PD_CTL (at 0x14148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO2_SOFT_START_CTL"
      sgroup "LDO2_SOFT_START_CTL (at 0x1414c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO2_CONFIG_CTL"
      sgroup "LDO2_CONFIG_CTL (at 0x14152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO2_VS_CTL"
      sgroup "LDO2_VS_CTL (at 0x14161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO2_SEC_ACCESS"
      sgroup "LDO2_SEC_ACCESS (at 0x141d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO2_PERPH_RESET_CTL1"
      sgroup "LDO2_PERPH_RESET_CTL1 (at 0x141d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL2"
      sgroup "LDO2_PERPH_RESET_CTL2 (at 0x141d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL3"
      sgroup "LDO2_PERPH_RESET_CTL3 (at 0x141da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL4"
      sgroup "LDO2_PERPH_RESET_CTL4 (at 0x141db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO2_INT_TEST1"
      sgroup "LDO2_INT_TEST1 (at 0x141e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO2_INT_TEST_VAL"
      sgroup "LDO2_INT_TEST_VAL (at 0x141e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO2_TEST1"
      sgroup "LDO2_TEST1 (at 0x141e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO2_TEST2"
      sgroup "LDO2_TEST2 (at 0x141e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO2_TRIM_NUM"
      sgroup "LDO2_TRIM_NUM (at 0x141f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO2_TRIM_CTRL"
      sgroup "LDO2_TRIM_CTRL (at 0x141f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO3"
  tree "LDO3"
    tree "LDO3_REVISION1"
      sgroup "LDO3_REVISION1 (at 0x14200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO3_REVISION2"
      sgroup "LDO3_REVISION2 (at 0x14201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO3_REVISION3"
      sgroup "LDO3_REVISION3 (at 0x14202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO3_REVISION4"
      sgroup "LDO3_REVISION4 (at 0x14203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO3_PERPH_TYPE"
      sgroup "LDO3_PERPH_TYPE (at 0x14204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO3_PERPH_SUBTYPE"
      sgroup "LDO3_PERPH_SUBTYPE (at 0x14205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO3_STATUS1"
      sgroup "LDO3_STATUS1 (at 0x14208)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO3_STATUS2"
      sgroup "LDO3_STATUS2 (at 0x14209)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO3_INT_RT_STS"
      sgroup "LDO3_INT_RT_STS (at 0x14210)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_SET_TYPE"
      sgroup "LDO3_INT_SET_TYPE (at 0x14211)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_HIGH"
      sgroup "LDO3_INT_POLARITY_HIGH (at 0x14212)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_LOW"
      sgroup "LDO3_INT_POLARITY_LOW (at 0x14213)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO3_INT_LATCHED_CLR"
      sgroup "LDO3_INT_LATCHED_CLR (at 0x14214)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO3_INT_EN_SET"
      sgroup "LDO3_INT_EN_SET (at 0x14215)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_EN_CLR"
      sgroup "LDO3_INT_EN_CLR (at 0x14216)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_LATCHED_STS"
      sgroup "LDO3_INT_LATCHED_STS (at 0x14218)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO3_INT_PENDING_STS"
      sgroup "LDO3_INT_PENDING_STS (at 0x14219)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_MID_SEL"
      sgroup "LDO3_INT_MID_SEL (at 0x1421a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO3_INT_PRIORITY"
      sgroup "LDO3_INT_PRIORITY (at 0x1421b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO3_VOLTAGE_CTL2"
      sgroup "LDO3_VOLTAGE_CTL2 (at 0x14241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO3_MODE_CTL2"
      sgroup "LDO3_MODE_CTL2 (at 0x14245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO3_EN_CTL"
      sgroup "LDO3_EN_CTL (at 0x14246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO3_PD_CTL"
      sgroup "LDO3_PD_CTL (at 0x14248)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO3_SOFT_START_CTL"
      sgroup "LDO3_SOFT_START_CTL (at 0x1424c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80424c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x424c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO3_CONFIG_CTL"
      sgroup "LDO3_CONFIG_CTL (at 0x14252)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO3_VS_CTL"
      sgroup "LDO3_VS_CTL (at 0x14261)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO3_SEC_ACCESS"
      sgroup "LDO3_SEC_ACCESS (at 0x142d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO3_PERPH_RESET_CTL1"
      sgroup "LDO3_PERPH_RESET_CTL1 (at 0x142d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL2"
      sgroup "LDO3_PERPH_RESET_CTL2 (at 0x142d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL3"
      sgroup "LDO3_PERPH_RESET_CTL3 (at 0x142da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL4"
      sgroup "LDO3_PERPH_RESET_CTL4 (at 0x142db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO3_INT_TEST1"
      sgroup "LDO3_INT_TEST1 (at 0x142e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO3_INT_TEST_VAL"
      sgroup "LDO3_INT_TEST_VAL (at 0x142e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO3_TEST1"
      sgroup "LDO3_TEST1 (at 0x142e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO3_TEST2"
      sgroup "LDO3_TEST2 (at 0x142e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO3_TRIM_NUM"
      sgroup "LDO3_TRIM_NUM (at 0x142f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO3_TRIM_CTRL"
      sgroup "LDO3_TRIM_CTRL (at 0x142f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO4"
  tree "LDO4"
    tree "LDO4_REVISION1"
      sgroup "LDO4_REVISION1 (at 0x14300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO4_REVISION2"
      sgroup "LDO4_REVISION2 (at 0x14301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO4_REVISION3"
      sgroup "LDO4_REVISION3 (at 0x14302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO4_REVISION4"
      sgroup "LDO4_REVISION4 (at 0x14303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO4_PERPH_TYPE"
      sgroup "LDO4_PERPH_TYPE (at 0x14304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO4_PERPH_SUBTYPE"
      sgroup "LDO4_PERPH_SUBTYPE (at 0x14305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO4_STATUS1"
      sgroup "LDO4_STATUS1 (at 0x14308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO4_STATUS2"
      sgroup "LDO4_STATUS2 (at 0x14309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO4_INT_RT_STS"
      sgroup "LDO4_INT_RT_STS (at 0x14310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_SET_TYPE"
      sgroup "LDO4_INT_SET_TYPE (at 0x14311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_HIGH"
      sgroup "LDO4_INT_POLARITY_HIGH (at 0x14312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_LOW"
      sgroup "LDO4_INT_POLARITY_LOW (at 0x14313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO4_INT_LATCHED_CLR"
      sgroup "LDO4_INT_LATCHED_CLR (at 0x14314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO4_INT_EN_SET"
      sgroup "LDO4_INT_EN_SET (at 0x14315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_EN_CLR"
      sgroup "LDO4_INT_EN_CLR (at 0x14316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_LATCHED_STS"
      sgroup "LDO4_INT_LATCHED_STS (at 0x14318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO4_INT_PENDING_STS"
      sgroup "LDO4_INT_PENDING_STS (at 0x14319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_MID_SEL"
      sgroup "LDO4_INT_MID_SEL (at 0x1431a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO4_INT_PRIORITY"
      sgroup "LDO4_INT_PRIORITY (at 0x1431b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO4_VOLTAGE_CTL2"
      sgroup "LDO4_VOLTAGE_CTL2 (at 0x14341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO4_MODE_CTL2"
      sgroup "LDO4_MODE_CTL2 (at 0x14345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO4_EN_CTL"
      sgroup "LDO4_EN_CTL (at 0x14346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO4_PD_CTL"
      sgroup "LDO4_PD_CTL (at 0x14348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO4_SOFT_START_CTL"
      sgroup "LDO4_SOFT_START_CTL (at 0x1434c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80434c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x434c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO4_CONFIG_CTL"
      sgroup "LDO4_CONFIG_CTL (at 0x14352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO4_SEC_ACCESS"
      sgroup "LDO4_SEC_ACCESS (at 0x143d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO4_PERPH_RESET_CTL1"
      sgroup "LDO4_PERPH_RESET_CTL1 (at 0x143d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL2"
      sgroup "LDO4_PERPH_RESET_CTL2 (at 0x143d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL3"
      sgroup "LDO4_PERPH_RESET_CTL3 (at 0x143da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL4"
      sgroup "LDO4_PERPH_RESET_CTL4 (at 0x143db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO4_INT_TEST1"
      sgroup "LDO4_INT_TEST1 (at 0x143e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO4_INT_TEST_VAL"
      sgroup "LDO4_INT_TEST_VAL (at 0x143e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO4_TEST1"
      sgroup "LDO4_TEST1 (at 0x143e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO4_TEST2"
      sgroup "LDO4_TEST2 (at 0x143e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO4_TRIM_NUM"
      sgroup "LDO4_TRIM_NUM (at 0x143f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO4_TRIM_CTRL"
      sgroup "LDO4_TRIM_CTRL (at 0x143f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO5"
  tree "LDO5"
    tree "LDO5_REVISION1"
      sgroup "LDO5_REVISION1 (at 0x14400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO5_REVISION2"
      sgroup "LDO5_REVISION2 (at 0x14401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO5_REVISION3"
      sgroup "LDO5_REVISION3 (at 0x14402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO5_REVISION4"
      sgroup "LDO5_REVISION4 (at 0x14403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO5_PERPH_TYPE"
      sgroup "LDO5_PERPH_TYPE (at 0x14404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO5_PERPH_SUBTYPE"
      sgroup "LDO5_PERPH_SUBTYPE (at 0x14405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO5_STATUS1"
      sgroup "LDO5_STATUS1 (at 0x14408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO5_STATUS2"
      sgroup "LDO5_STATUS2 (at 0x14409)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO5_INT_RT_STS"
      sgroup "LDO5_INT_RT_STS (at 0x14410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_SET_TYPE"
      sgroup "LDO5_INT_SET_TYPE (at 0x14411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_HIGH"
      sgroup "LDO5_INT_POLARITY_HIGH (at 0x14412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_LOW"
      sgroup "LDO5_INT_POLARITY_LOW (at 0x14413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO5_INT_LATCHED_CLR"
      sgroup "LDO5_INT_LATCHED_CLR (at 0x14414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO5_INT_EN_SET"
      sgroup "LDO5_INT_EN_SET (at 0x14415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_EN_CLR"
      sgroup "LDO5_INT_EN_CLR (at 0x14416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_LATCHED_STS"
      sgroup "LDO5_INT_LATCHED_STS (at 0x14418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO5_INT_PENDING_STS"
      sgroup "LDO5_INT_PENDING_STS (at 0x14419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_MID_SEL"
      sgroup "LDO5_INT_MID_SEL (at 0x1441a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO5_INT_PRIORITY"
      sgroup "LDO5_INT_PRIORITY (at 0x1441b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO5_VOLTAGE_CTL2"
      sgroup "LDO5_VOLTAGE_CTL2 (at 0x14441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO5_MODE_CTL2"
      sgroup "LDO5_MODE_CTL2 (at 0x14445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO5_EN_CTL"
      sgroup "LDO5_EN_CTL (at 0x14446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO5_PD_CTL"
      sgroup "LDO5_PD_CTL (at 0x14448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO5_SOFT_START_CTL"
      sgroup "LDO5_SOFT_START_CTL (at 0x1444c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80444c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x444c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO5_CONFIG_CTL"
      sgroup "LDO5_CONFIG_CTL (at 0x14452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO5_SEC_ACCESS"
      sgroup "LDO5_SEC_ACCESS (at 0x144d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO5_PERPH_RESET_CTL1"
      sgroup "LDO5_PERPH_RESET_CTL1 (at 0x144d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL2"
      sgroup "LDO5_PERPH_RESET_CTL2 (at 0x144d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL3"
      sgroup "LDO5_PERPH_RESET_CTL3 (at 0x144da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL4"
      sgroup "LDO5_PERPH_RESET_CTL4 (at 0x144db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO5_INT_TEST1"
      sgroup "LDO5_INT_TEST1 (at 0x144e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO5_INT_TEST_VAL"
      sgroup "LDO5_INT_TEST_VAL (at 0x144e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO5_TEST1"
      sgroup "LDO5_TEST1 (at 0x144e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO5_TEST2"
      sgroup "LDO5_TEST2 (at 0x144e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO5_TRIM_NUM"
      sgroup "LDO5_TRIM_NUM (at 0x144f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO5_TRIM_CTRL"
      sgroup "LDO5_TRIM_CTRL (at 0x144f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO6"
  tree "LDO6"
    tree "LDO6_REVISION1"
      sgroup "LDO6_REVISION1 (at 0x14500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO6_REVISION2"
      sgroup "LDO6_REVISION2 (at 0x14501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO6_REVISION3"
      sgroup "LDO6_REVISION3 (at 0x14502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO6_REVISION4"
      sgroup "LDO6_REVISION4 (at 0x14503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO6_PERPH_TYPE"
      sgroup "LDO6_PERPH_TYPE (at 0x14504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO6_PERPH_SUBTYPE"
      sgroup "LDO6_PERPH_SUBTYPE (at 0x14505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO6_STATUS1"
      sgroup "LDO6_STATUS1 (at 0x14508)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO6_STATUS2"
      sgroup "LDO6_STATUS2 (at 0x14509)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO6_INT_RT_STS"
      sgroup "LDO6_INT_RT_STS (at 0x14510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_SET_TYPE"
      sgroup "LDO6_INT_SET_TYPE (at 0x14511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_HIGH"
      sgroup "LDO6_INT_POLARITY_HIGH (at 0x14512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_LOW"
      sgroup "LDO6_INT_POLARITY_LOW (at 0x14513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO6_INT_LATCHED_CLR"
      sgroup "LDO6_INT_LATCHED_CLR (at 0x14514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO6_INT_EN_SET"
      sgroup "LDO6_INT_EN_SET (at 0x14515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_EN_CLR"
      sgroup "LDO6_INT_EN_CLR (at 0x14516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_LATCHED_STS"
      sgroup "LDO6_INT_LATCHED_STS (at 0x14518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO6_INT_PENDING_STS"
      sgroup "LDO6_INT_PENDING_STS (at 0x14519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_MID_SEL"
      sgroup "LDO6_INT_MID_SEL (at 0x1451a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO6_INT_PRIORITY"
      sgroup "LDO6_INT_PRIORITY (at 0x1451b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO6_VOLTAGE_CTL2"
      sgroup "LDO6_VOLTAGE_CTL2 (at 0x14541)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO6_MODE_CTL2"
      sgroup "LDO6_MODE_CTL2 (at 0x14545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO6_EN_CTL"
      sgroup "LDO6_EN_CTL (at 0x14546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO6_PD_CTL"
      sgroup "LDO6_PD_CTL (at 0x14548)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO6_SOFT_START_CTL"
      sgroup "LDO6_SOFT_START_CTL (at 0x1454c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80454c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x454c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO6_CONFIG_CTL"
      sgroup "LDO6_CONFIG_CTL (at 0x14552)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO6_SEC_ACCESS"
      sgroup "LDO6_SEC_ACCESS (at 0x145d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO6_PERPH_RESET_CTL1"
      sgroup "LDO6_PERPH_RESET_CTL1 (at 0x145d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL2"
      sgroup "LDO6_PERPH_RESET_CTL2 (at 0x145d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL3"
      sgroup "LDO6_PERPH_RESET_CTL3 (at 0x145da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL4"
      sgroup "LDO6_PERPH_RESET_CTL4 (at 0x145db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO6_INT_TEST1"
      sgroup "LDO6_INT_TEST1 (at 0x145e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO6_INT_TEST_VAL"
      sgroup "LDO6_INT_TEST_VAL (at 0x145e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO6_TEST1"
      sgroup "LDO6_TEST1 (at 0x145e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO6_TEST2"
      sgroup "LDO6_TEST2 (at 0x145e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO6_TRIM_NUM"
      sgroup "LDO6_TRIM_NUM (at 0x145f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO6_TRIM_CTRL"
      sgroup "LDO6_TRIM_CTRL (at 0x145f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO7"
  tree "LDO7"
    tree "LDO7_REVISION1"
      sgroup "LDO7_REVISION1 (at 0x14600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO7_REVISION2"
      sgroup "LDO7_REVISION2 (at 0x14601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO7_REVISION3"
      sgroup "LDO7_REVISION3 (at 0x14602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO7_REVISION4"
      sgroup "LDO7_REVISION4 (at 0x14603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO7_PERPH_TYPE"
      sgroup "LDO7_PERPH_TYPE (at 0x14604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO7_PERPH_SUBTYPE"
      sgroup "LDO7_PERPH_SUBTYPE (at 0x14605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO7_STATUS1"
      sgroup "LDO7_STATUS1 (at 0x14608)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO7_STATUS2"
      sgroup "LDO7_STATUS2 (at 0x14609)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO7_INT_RT_STS"
      sgroup "LDO7_INT_RT_STS (at 0x14610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_SET_TYPE"
      sgroup "LDO7_INT_SET_TYPE (at 0x14611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_HIGH"
      sgroup "LDO7_INT_POLARITY_HIGH (at 0x14612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_LOW"
      sgroup "LDO7_INT_POLARITY_LOW (at 0x14613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO7_INT_LATCHED_CLR"
      sgroup "LDO7_INT_LATCHED_CLR (at 0x14614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO7_INT_EN_SET"
      sgroup "LDO7_INT_EN_SET (at 0x14615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_EN_CLR"
      sgroup "LDO7_INT_EN_CLR (at 0x14616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_LATCHED_STS"
      sgroup "LDO7_INT_LATCHED_STS (at 0x14618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO7_INT_PENDING_STS"
      sgroup "LDO7_INT_PENDING_STS (at 0x14619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_MID_SEL"
      sgroup "LDO7_INT_MID_SEL (at 0x1461a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO7_INT_PRIORITY"
      sgroup "LDO7_INT_PRIORITY (at 0x1461b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO7_VOLTAGE_CTL2"
      sgroup "LDO7_VOLTAGE_CTL2 (at 0x14641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO7_MODE_CTL2"
      sgroup "LDO7_MODE_CTL2 (at 0x14645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO7_EN_CTL"
      sgroup "LDO7_EN_CTL (at 0x14646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO7_PD_CTL"
      sgroup "LDO7_PD_CTL (at 0x14648)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO7_SOFT_START_CTL"
      sgroup "LDO7_SOFT_START_CTL (at 0x1464c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO7_CONFIG_CTL"
      sgroup "LDO7_CONFIG_CTL (at 0x14652)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO7_SEC_ACCESS"
      sgroup "LDO7_SEC_ACCESS (at 0x146d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO7_PERPH_RESET_CTL1"
      sgroup "LDO7_PERPH_RESET_CTL1 (at 0x146d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL2"
      sgroup "LDO7_PERPH_RESET_CTL2 (at 0x146d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL3"
      sgroup "LDO7_PERPH_RESET_CTL3 (at 0x146da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL4"
      sgroup "LDO7_PERPH_RESET_CTL4 (at 0x146db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO7_INT_TEST1"
      sgroup "LDO7_INT_TEST1 (at 0x146e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO7_INT_TEST_VAL"
      sgroup "LDO7_INT_TEST_VAL (at 0x146e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO7_TEST1"
      sgroup "LDO7_TEST1 (at 0x146e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO7_TEST2"
      sgroup "LDO7_TEST2 (at 0x146e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO7_TRIM_NUM"
      sgroup "LDO7_TRIM_NUM (at 0x146f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO7_TRIM_CTRL"
      sgroup "LDO7_TRIM_CTRL (at 0x146f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO8"
  tree "LDO8"
    tree "LDO8_REVISION1"
      sgroup "LDO8_REVISION1 (at 0x14700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO8_REVISION2"
      sgroup "LDO8_REVISION2 (at 0x14701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO8_REVISION3"
      sgroup "LDO8_REVISION3 (at 0x14702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO8_REVISION4"
      sgroup "LDO8_REVISION4 (at 0x14703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO8_PERPH_TYPE"
      sgroup "LDO8_PERPH_TYPE (at 0x14704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO8_PERPH_SUBTYPE"
      sgroup "LDO8_PERPH_SUBTYPE (at 0x14705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO8_STATUS1"
      sgroup "LDO8_STATUS1 (at 0x14708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO8_STATUS2"
      sgroup "LDO8_STATUS2 (at 0x14709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO8_INT_RT_STS"
      sgroup "LDO8_INT_RT_STS (at 0x14710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_SET_TYPE"
      sgroup "LDO8_INT_SET_TYPE (at 0x14711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_HIGH"
      sgroup "LDO8_INT_POLARITY_HIGH (at 0x14712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_LOW"
      sgroup "LDO8_INT_POLARITY_LOW (at 0x14713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO8_INT_LATCHED_CLR"
      sgroup "LDO8_INT_LATCHED_CLR (at 0x14714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO8_INT_EN_SET"
      sgroup "LDO8_INT_EN_SET (at 0x14715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_EN_CLR"
      sgroup "LDO8_INT_EN_CLR (at 0x14716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_LATCHED_STS"
      sgroup "LDO8_INT_LATCHED_STS (at 0x14718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO8_INT_PENDING_STS"
      sgroup "LDO8_INT_PENDING_STS (at 0x14719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_MID_SEL"
      sgroup "LDO8_INT_MID_SEL (at 0x1471a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO8_INT_PRIORITY"
      sgroup "LDO8_INT_PRIORITY (at 0x1471b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO8_VOLTAGE_CTL2"
      sgroup "LDO8_VOLTAGE_CTL2 (at 0x14741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO8_MODE_CTL2"
      sgroup "LDO8_MODE_CTL2 (at 0x14745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO8_EN_CTL"
      sgroup "LDO8_EN_CTL (at 0x14746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO8_PD_CTL"
      sgroup "LDO8_PD_CTL (at 0x14748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO8_SOFT_START_CTL"
      sgroup "LDO8_SOFT_START_CTL (at 0x1474c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80474c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x474c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO8_CONFIG_CTL"
      sgroup "LDO8_CONFIG_CTL (at 0x14752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO8_SEC_ACCESS"
      sgroup "LDO8_SEC_ACCESS (at 0x147d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO8_PERPH_RESET_CTL1"
      sgroup "LDO8_PERPH_RESET_CTL1 (at 0x147d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL2"
      sgroup "LDO8_PERPH_RESET_CTL2 (at 0x147d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL3"
      sgroup "LDO8_PERPH_RESET_CTL3 (at 0x147da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL4"
      sgroup "LDO8_PERPH_RESET_CTL4 (at 0x147db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO8_INT_TEST1"
      sgroup "LDO8_INT_TEST1 (at 0x147e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO8_INT_TEST_VAL"
      sgroup "LDO8_INT_TEST_VAL (at 0x147e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO8_TEST1"
      sgroup "LDO8_TEST1 (at 0x147e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO8_TEST2"
      sgroup "LDO8_TEST2 (at 0x147e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO8_TRIM_NUM"
      sgroup "LDO8_TRIM_NUM (at 0x147f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO8_TRIM_CTRL"
      sgroup "LDO8_TRIM_CTRL (at 0x147f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO9"
  tree "LDO9"
    tree "LDO9_REVISION1"
      sgroup "LDO9_REVISION1 (at 0x14800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO9_REVISION2"
      sgroup "LDO9_REVISION2 (at 0x14801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO9_REVISION3"
      sgroup "LDO9_REVISION3 (at 0x14802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO9_REVISION4"
      sgroup "LDO9_REVISION4 (at 0x14803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO9_PERPH_TYPE"
      sgroup "LDO9_PERPH_TYPE (at 0x14804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO9_PERPH_SUBTYPE"
      sgroup "LDO9_PERPH_SUBTYPE (at 0x14805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO9_STATUS1"
      sgroup "LDO9_STATUS1 (at 0x14808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_LDO                               = " "0 (OFF_OR_NON_BYPASS),1 (ON_AND_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO9_STATUS2"
      sgroup "LDO9_STATUS2 (at 0x14809)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
    tree.end
    tree "LDO9_INT_RT_STS"
      sgroup "LDO9_INT_RT_STS (at 0x14810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_SET_TYPE"
      sgroup "LDO9_INT_SET_TYPE (at 0x14811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_HIGH"
      sgroup "LDO9_INT_POLARITY_HIGH (at 0x14812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_LOW"
      sgroup "LDO9_INT_POLARITY_LOW (at 0x14813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO9_INT_LATCHED_CLR"
      sgroup "LDO9_INT_LATCHED_CLR (at 0x14814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO9_INT_EN_SET"
      sgroup "LDO9_INT_EN_SET (at 0x14815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_EN_CLR"
      sgroup "LDO9_INT_EN_CLR (at 0x14816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_LATCHED_STS"
      sgroup "LDO9_INT_LATCHED_STS (at 0x14818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO9_INT_PENDING_STS"
      sgroup "LDO9_INT_PENDING_STS (at 0x14819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_MID_SEL"
      sgroup "LDO9_INT_MID_SEL (at 0x1481a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO9_INT_PRIORITY"
      sgroup "LDO9_INT_PRIORITY (at 0x1481b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO9_VOLTAGE_CTL2"
      sgroup "LDO9_VOLTAGE_CTL2 (at 0x14841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO9_MODE_CTL2"
      sgroup "LDO9_MODE_CTL2 (at 0x14845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
    tree.end
    tree "LDO9_EN_CTL"
      sgroup "LDO9_EN_CTL (at 0x14846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO9_PD_CTL"
      sgroup "LDO9_PD_CTL (at 0x14848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO9_SOFT_START_CTL"
      sgroup "LDO9_SOFT_START_CTL (at 0x1484c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80484c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x484c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO9_CONFIG_CTL"
      sgroup "LDO9_CONFIG_CTL (at 0x14852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_TRAN_ENH_EN                         = " "0 (MODE_TRAN_ENH_DISABLED),1 (MODE_TRAN_ENH_ENABLED)"
    tree.end
    tree "LDO9_SEC_ACCESS"
      sgroup "LDO9_SEC_ACCESS (at 0x148d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO9_PERPH_RESET_CTL1"
      sgroup "LDO9_PERPH_RESET_CTL1 (at 0x148d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL2"
      sgroup "LDO9_PERPH_RESET_CTL2 (at 0x148d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL3"
      sgroup "LDO9_PERPH_RESET_CTL3 (at 0x148da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL4"
      sgroup "LDO9_PERPH_RESET_CTL4 (at 0x148db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO9_INT_TEST1"
      sgroup "LDO9_INT_TEST1 (at 0x148e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO9_INT_TEST_VAL"
      sgroup "LDO9_INT_TEST_VAL (at 0x148e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO9_TEST1"
      sgroup "LDO9_TEST1 (at 0x148e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO9_TEST2"
      sgroup "LDO9_TEST2 (at 0x148e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0 (DTEST_NONE),1 (DTEST_VREG_OK_DI),2 (DTEST_SOFTSTART_DONE_DI),3 (reserved)"
    tree.end
    tree "LDO9_TRIM_NUM"
      sgroup "LDO9_TRIM_NUM (at 0x148f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO9_TRIM_CTRL"
      sgroup "LDO9_TRIM_CTRL (at 0x148f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO_RFCLK"
  tree "LDO_RFCLK"
    tree "LDO_RFCLK_REVISION1"
      sgroup "LDO_RFCLK_REVISION1 (at 0x15300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION2"
      sgroup "LDO_RFCLK_REVISION2 (at 0x15301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION3"
      sgroup "LDO_RFCLK_REVISION3 (at 0x15302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_RFCLK_REVISION4"
      sgroup "LDO_RFCLK_REVISION4 (at 0x15303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_RFCLK_PERPH_TYPE"
      sgroup "LDO_RFCLK_PERPH_TYPE (at 0x15304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_RFCLK_PERPH_SUBTYPE"
      sgroup "LDO_RFCLK_PERPH_SUBTYPE (at 0x15305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_RFCLK_STATUS1"
      sgroup "LDO_RFCLK_STATUS1 (at 0x15308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL1"
      sgroup "LDO_RFCLK_VOLTAGE_CTL1 (at 0x15340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_RFCLK_VOLTAGE_CTL2"
      sgroup "LDO_RFCLK_VOLTAGE_CTL2 (at 0x15341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_RFCLK_MODE_CTL2"
      sgroup "LDO_RFCLK_MODE_CTL2 (at 0x15345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_RFCLK_EN_CTL"
      sgroup "LDO_RFCLK_EN_CTL (at 0x15346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_RFCLK_SEC_ACCESS"
      sgroup "LDO_RFCLK_SEC_ACCESS (at 0x153d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL1"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL1 (at 0x153d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL2"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL2 (at 0x153d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL3"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL3 (at 0x153da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_RFCLK_PERPH_RESET_CTL4"
      sgroup "LDO_RFCLK_PERPH_RESET_CTL4 (at 0x153db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_RFCLK_TEST1"
      sgroup "LDO_RFCLK_TEST1 (at 0x153e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO_XO"
  tree "LDO_XO"
    tree "LDO_XO_REVISION1"
      sgroup "LDO_XO_REVISION1 (at 0x15200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION2"
      sgroup "LDO_XO_REVISION2 (at 0x15201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO_XO_REVISION3"
      sgroup "LDO_XO_REVISION3 (at 0x15202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO_XO_REVISION4"
      sgroup "LDO_XO_REVISION4 (at 0x15203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO_XO_PERPH_TYPE"
      sgroup "LDO_XO_PERPH_TYPE (at 0x15204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO_XO_PERPH_SUBTYPE"
      sgroup "LDO_XO_PERPH_SUBTYPE (at 0x15205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO_XO_STATUS1"
      sgroup "LDO_XO_STATUS1 (at 0x15208)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL1"
      sgroup "LDO_XO_VOLTAGE_CTL1 (at 0x15240)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO_XO_VOLTAGE_CTL2"
      sgroup "LDO_XO_VOLTAGE_CTL2 (at 0x15241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO_XO_MODE_CTL2"
      sgroup "LDO_XO_MODE_CTL2 (at 0x15245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO_XO_EN_CTL"
      sgroup "LDO_XO_EN_CTL (at 0x15246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO_XO_SEC_ACCESS"
      sgroup "LDO_XO_SEC_ACCESS (at 0x152d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL1"
      sgroup "LDO_XO_PERPH_RESET_CTL1 (at 0x152d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL2"
      sgroup "LDO_XO_PERPH_RESET_CTL2 (at 0x152d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL3"
      sgroup "LDO_XO_PERPH_RESET_CTL3 (at 0x152da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO_XO_PERPH_RESET_CTL4"
      sgroup "LDO_XO_PERPH_RESET_CTL4 (at 0x152db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO_XO_TEST1"
      sgroup "LDO_XO_TEST1 (at 0x152e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      sgroup "MISC_STATUS1 (at 0x908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GP1RESET                                 = " "0, 1"
    tree.end
    tree "MISC_STATUS2"
      sgroup "MISC_STATUS2 (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0, 1"
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x7 1 "  [ 7: 1]   MISC_CTL                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VDD_LDO_XO_SEL                           = " "0, 1"
    tree.end
    tree "MISC_GP1RESET_CTL1"
      sgroup "MISC_GP1RESET_CTL1 (at 0x947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO3_GP1RESET_POLARITY                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GPIO3_GP1RESET_EN                        = " "0, 1"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED3),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED7)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED3),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED7)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
