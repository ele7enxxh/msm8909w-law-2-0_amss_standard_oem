entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      sgroup "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      sgroup "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      sgroup "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      sgroup "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      sgroup "BCLK_GEN_MAIN_STATUS (at 0x11008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      sgroup "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      sgroup "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      sgroup "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      sgroup "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      sgroup "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      sgroup "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      sgroup "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      sgroup "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      sgroup "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      sgroup "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      sgroup "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      sgroup "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      sgroup "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      sgroup "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      sgroup "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      sgroup "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      sgroup "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XORC19M2_CLK_SEL                         = " "0 (DIV_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (DIV_CLK_RC_19M),2 (DIV_CLK_XO_19M),3 (DIV_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_32K_RC                               = " "0 (CLK19M_DIV),1 (CLK32K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      sgroup "LDO1_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      sgroup "LDO1_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      sgroup "LDO1_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      sgroup "LDO1_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      sgroup "LDO1_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      sgroup "LDO1_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      sgroup "LDO1_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO1_STATUS2"
      sgroup "LDO1_STATUS2 (at 0x14009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      sgroup "LDO1_STATUS3 (at 0x1400a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      sgroup "LDO1_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      sgroup "LDO1_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      sgroup "LDO1_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      sgroup "LDO1_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      sgroup "LDO1_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      sgroup "LDO1_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      sgroup "LDO1_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      sgroup "LDO1_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      sgroup "LDO1_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      sgroup "LDO1_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      sgroup "LDO1_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      sgroup "LDO1_VOLTAGE_CTL1 (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      sgroup "LDO1_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      sgroup "LDO1_MODE_CTL2 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      sgroup "LDO1_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      sgroup "LDO1_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      sgroup "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      sgroup "LDO1_SOFT_START_CTL (at 0x1404c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      sgroup "LDO1_CONFIG_CTL (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_VS_CTL"
      sgroup "LDO1_VS_CTL (at 0x14061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      sgroup "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      sgroup "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      sgroup "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      sgroup "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      sgroup "LDO1_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      sgroup "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      sgroup "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      sgroup "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      sgroup "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      sgroup "LDO1_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      sgroup "LDO1_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      sgroup "LDO1_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      sgroup "LDO1_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      sgroup "LDO1_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      sgroup "LDO1_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_TEST_CONNECT"
      sgroup "MISC_TEST_CONNECT (at 0x940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RFU                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_CONNECT                            = " "0 (ATEST_CONNECT_DISABLED),1 (ATEST_CONNECT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONNECT_1                          = " "0 (DTEST_CONNECT_H_TO_L_DISABLED),1 (DTEST_CONNECT_H_TO_L_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONNECT_0                          = " "0 (DTEST_CONNECT_L_TO_H_DISABLED),1 (DTEST_CONNECT_H_TO_L_ENABLED)"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_CONNECT_DISABLED),1 (DVDD_CONNECT_ENABLED),2 (reserved),3 (reserved)"
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_IBG_DLY_DISABLED),1 (BYPASS_IBG_DLY_ENABLED)"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      sgroup "PBS_CLIENT5_STATUS1 (at 0x7609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      sgroup "PBS_CLIENT6_STATUS1 (at 0x7709)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      sgroup "PBS_CLIENT7_REVISION1 (at 0x7800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      sgroup "PBS_CLIENT7_REVISION2 (at 0x7801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      sgroup "PBS_CLIENT7_REVISION3 (at 0x7802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      sgroup "PBS_CLIENT7_REVISION4 (at 0x7803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      sgroup "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      sgroup "PBS_CLIENT7_STATUS0 (at 0x7808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      sgroup "PBS_CLIENT7_STATUS1 (at 0x7809)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      sgroup "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      sgroup "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      sgroup "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      sgroup "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      sgroup "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      sgroup "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      sgroup "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      sgroup "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      sgroup "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      sgroup "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      sgroup "PBS_CLIENT7_EN_CTL (at 0x7846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      sgroup "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      sgroup "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      sgroup "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_LSB_n"
      sgroup "PBS_CORE_TRIG_START_ADDR_LSB_n (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_MSB_n"
      sgroup "PBS_CORE_TRIG_START_ADDR_MSB_n (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_50K_EN                             = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0 (LPM),1 (HPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_FSM_CTL"
      sgroup "PON_FSM_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_FSM                                  = "
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM_STATE                                = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      sgroup "REVID_STATUS1 (at 0x108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0 (OP4_GND),1 (reserved),2 (OP4_HIZ),3 (OP4_VDD)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0 (OP3_GND),1 (reserved),2 (OP3_HIZ),3 (OP3_VDD)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0 (OP2_GND),1 (reserved),2 (OP2_HIZ),3 (OP2_VDD)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0 (OP1_GND),1 (reserved),2 (OP1_HIZ),3 (OP1_VDD)"
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      sgroup "REVID_TEST1 (at 0x1e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (DTEST_DISABLED),1 (DTEST_OPT1),2 (DTEST_OPT2),3 (DTEST_OPT3),4 (DTEST_OPT4),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      sgroup "S1_CTRL_STATUS (at 0x11408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      sgroup "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      sgroup "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      sgroup "S1_CTRL_PFM_CTL (at 0x11444)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST_FALSE),1 (PFM_VOLT_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      sgroup "S1_CTRL_MODE_CTL (at 0x11445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      sgroup "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S1_CTRL_GM_CTL"
      sgroup "S1_CTRL_GM_CTL (at 0x11452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      sgroup "S1_CTRL_RZ_CTL (at 0x11453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      sgroup "S1_CTRL_ISNS_CTRL (at 0x11455)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      sgroup "S1_CTRL_SAW_CTL (at 0x11456)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      sgroup "S1_CTRL_DMAX_CTL (at 0x11458)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      sgroup "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      sgroup "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      sgroup "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      sgroup "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      sgroup "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_VGA_CTL"
      sgroup "S1_CTRL_PS_VGA_CTL (at 0x1145e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      sgroup "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      sgroup "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_FT_CTL"
      sgroup "S1_CTRL_FT_CTL (at 0x11462)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S1_CTRL_QMODE_SHADOW"
      sgroup "S1_CTRL_QMODE_SHADOW (at 0x11463)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S1_CTRL_UL_LL_CTRL"
      sgroup "S1_CTRL_UL_LL_CTRL (at 0x11468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      sgroup "S1_CTRL_UL_VOLTAGE (at 0x11469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_LL_VOLTAGE"
      sgroup "S1_CTRL_LL_VOLTAGE (at 0x1146b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_OCP"
      sgroup "S1_CTRL_OCP (at 0x1146c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      sgroup "S1_CTRL_CTLR_MISC (at 0x1147a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80147a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      sgroup "S1_CTRL_SEC_ACCESS (at 0x114d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      sgroup "S1_CTRL_CTLR_TEST (at 0x114e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      sgroup "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      sgroup "S1_CTRL_CTL_TRIM2 (at 0x114f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      sgroup "S1_CTRL_CTL_TRIM3 (at 0x114f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      sgroup "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      sgroup "S1_FREQ_CLK_ENABLE (at 0x11646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      sgroup "S1_FREQ_CLK_PHASE (at 0x11651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      sgroup "S1_FREQ_GANG_CTL1 (at 0x116c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      sgroup "S1_FREQ_GANG_CTL2 (at 0x116c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      sgroup "S1_FREQ_TEST1 (at 0x116e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      sgroup "S1_PS_SOFT_START_CTL (at 0x1154c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      sgroup "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL1"
      sgroup "S1_PS_DEAD_TIME_CTRL1 (at 0x11571)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      sgroup "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      sgroup "S1_PS_BLNK_TIME_CTL (at 0x11573)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S1_PS_INZERO_CTL"
      sgroup "S1_PS_INZERO_CTL (at 0x11574)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      sgroup "S1_PS_DIG_FSM_CTL (at 0x11575)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      sgroup "S1_PS_PWR_STG_MISC (at 0x11579)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      sgroup "S1_PS_SEC_ACCESS (at 0x115d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      sgroup "S1_PS_FORCE_FET_TEST (at 0x115e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      sgroup "S1_PS_PWR_STG_TEST (at 0x115e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      sgroup "S1_PS_PS_TRIM1 (at 0x115f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      sgroup "S1_PS_PS_TRIM2 (at 0x115f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      sgroup "S2_CTRL_REVISION1 (at 0x11700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      sgroup "S2_CTRL_REVISION2 (at 0x11701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      sgroup "S2_CTRL_REVISION3 (at 0x11702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      sgroup "S2_CTRL_REVISION4 (at 0x11703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      sgroup "S2_CTRL_PERPH_TYPE (at 0x11704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      sgroup "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      sgroup "S2_CTRL_STATUS_1 (at 0x11708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_2"
      sgroup "S2_CTRL_STATUS_2 (at 0x11709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_3"
      sgroup "S2_CTRL_STATUS_3 (at 0x1170a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_4"
      sgroup "S2_CTRL_STATUS_4 (at 0x1170b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S2_CTRL_STATUS_5"
      sgroup "S2_CTRL_STATUS_5 (at 0x1170c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      sgroup "S2_CTRL_INT_RT_STS (at 0x11710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      sgroup "S2_CTRL_INT_SET_TYPE (at 0x11711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      sgroup "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      sgroup "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      sgroup "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      sgroup "S2_CTRL_INT_EN_SET (at 0x11715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      sgroup "S2_CTRL_INT_EN_CLR (at 0x11716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      sgroup "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      sgroup "S2_CTRL_INT_PENDING_STS (at 0x11719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      sgroup "S2_CTRL_INT_MID_SEL (at 0x1171a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      sgroup "S2_CTRL_INT_PRIORITY (at 0x1171b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      sgroup "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      sgroup "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      sgroup "S2_CTRL_VSET_VALID (at 0x11742)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_MPPFM_VOFFSET"
      sgroup "S2_CTRL_MPPFM_VOFFSET (at 0x11744)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      sgroup "S2_CTRL_MODE_CTL (at 0x11745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      sgroup "S2_CTRL_EN_CTL (at 0x11746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      sgroup "S2_CTRL_PD_CTL (at 0x11748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      sgroup "S2_CTRL_FREQ_CTL (at 0x11750)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      sgroup "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      sgroup "S2_CTRL_PHASE_CTL (at 0x11752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      sgroup "S2_CTRL_PHASE_ID (at 0x11753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_CTRL_PHASE_CNT_MAX"
      sgroup "S2_CTRL_PHASE_CNT_MAX (at 0x11754)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_CTRL_PH_READY"
      sgroup "S2_CTRL_PH_READY (at 0x11755)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S2_CTRL_SS_CTL"
      sgroup "S2_CTRL_SS_CTL (at 0x11760)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_VS_CTL"
      sgroup "S2_CTRL_VS_CTL (at 0x11761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      sgroup "S2_CTRL_CORR_CFG (at 0x11762)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      sgroup "S2_CTRL_RAMP_CFG (at 0x11763)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      sgroup "S2_CTRL_COMPENS_CFG (at 0x11764)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_100KHZ),1 (BP_LPF_280KHZ),2 (BP_LPF_460KHZ),3 (BP_LPF_640KHZ),4 (BP_LPF_780KHZ),5 (BP_LPF_990KHZ),6 (BP_LPF_1130KHZ),7 (BP_LPF_1340KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_100KHZ),1 (BP_LPF2_280KHZ),2 (BP_LPF2_460KHZ),3 (BP_LPF2_640KHZ),4 (BP_LPF2_780KHZ),5 (BP_LPF2_990KHZ),6 (BP_LPF2_1130KHZ),7 (BP_LPF2_1340KHZ)"
    tree.end
    tree "S2_CTRL_CFG_VREG_MON"
      sgroup "S2_CTRL_CFG_VREG_MON (at 0x11765)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_CFG_VREG_OCP"
      sgroup "S2_CTRL_CFG_VREG_OCP (at 0x11766)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      sgroup "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      sgroup "S2_CTRL_UL_LL_CTL (at 0x11768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      sgroup "S2_CTRL_VSET_ULS (at 0x11769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      sgroup "S2_CTRL_ULS_VALID (at 0x1176a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      sgroup "S2_CTRL_VSET_LLS (at 0x1176b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      sgroup "S2_CTRL_LLS_VALID (at 0x1176c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      sgroup "S2_CTRL_GPL_HI (at 0x1176d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      sgroup "S2_CTRL_GPL_LO (at 0x1176e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_FB_FILT_CFG"
      sgroup "S2_CTRL_FB_FILT_CFG (at 0x1176f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_0P47MHZ),1 (FBLP_CORNER_1P5MHZ),2 (FBLP_CORNER_6MHZ),3 (FBLP_CORNER_20MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S2_CTRL_VDIP_CFG"
      sgroup "S2_CTRL_VDIP_CFG (at 0x11771)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_BURST_ENABLED_1),3 (VDIP_BURST_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S2_CTRL_MPH_STROBE"
      sgroup "S2_CTRL_MPH_STROBE (at 0x11779)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      sgroup "S2_CTRL_MODE_FSM_MASK (at 0x117a0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_MODE_FSM_WAITS_1"
      sgroup "S2_CTRL_MODE_FSM_WAITS_1 (at 0x117a1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S2_CTRL_MODE_FSM_WAIT_2"
      sgroup "S2_CTRL_MODE_FSM_WAIT_2 (at 0x117a2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      sgroup "S2_CTRL_GATE_DRV_MUX (at 0x117a3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      sgroup "S2_CTRL_CORR_DUTY_MUX (at 0x117a4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_1"
      sgroup "S2_CTRL_EN_OPTIONS_DFT_1 (at 0x117a5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_2"
      sgroup "S2_CTRL_EN_OPTIONS_DFT_2 (at 0x117a6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      sgroup "S2_CTRL_MPHASE_IDAC (at 0x117a7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_1_SHADOW"
      sgroup "S2_CTRL_EN_OPTIONS_DFT_1_SHADOW (at 0x117a8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_2_SHADOW"
      sgroup "S2_CTRL_EN_OPTIONS_DFT_2_SHADOW (at 0x117a9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S2_CTRL_ZX_ADAPT_CTL_SHADOW"
      sgroup "S2_CTRL_ZX_ADAPT_CTL_SHADOW (at 0x117aa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_1"
      sgroup "S2_CTRL_ANTI_ESL_CFG_1 (at 0x117ac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DUTY_FB_SEL_CORR                         = " "0 (DUTY_FB_CORR_PWM),1 (DUTY_FB_CORR_AFSM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DUTY_FB_SEL_COMPENS                      = " "0 (DUTY_FB_COMPENS_PWM),1 (DUTY_FB_COMPENS_AFSM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DUTY_FB_SEL_ANTI_ESL                     = " "0 (DUTY_FB_ANTIESL_PWM),1 (DUTY_FB_ANTIESL_AFSM)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_UNLATCHED_2),2 (GRDV_FULL_LATCHED),3 (GDRV_HALF_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_2"
      sgroup "S2_CTRL_ANTI_ESL_CFG_2 (at 0x117ad)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_2                                  = " "0 (SPARE_2_LO),1 (SPARE_2_HI)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_1                                  = " "0 (LPM_IDAC_REF_DISABL),1 (LPM_IDAC_REF_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_0                                  = " "0 (SPARE_0_LO),1 (SPARE_0_HI)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ESL_PULSE_RESET_EN                       = " "0 (ESL_PULSE_RST_DISABL),1 (ESL_PULSE_RST_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      sgroup "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      sgroup "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      sgroup "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      sgroup "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      sgroup "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      sgroup "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      sgroup "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      sgroup "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      sgroup "S2_CTRL_GANG_CTL1 (at 0x117c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      sgroup "S2_CTRL_GANG_CTL2 (at 0x117c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      sgroup "S2_CTRL_SEC_ACCESS (at 0x117d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      sgroup "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      sgroup "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      sgroup "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      sgroup "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      sgroup "S2_CTRL_INT_TEST1 (at 0x117e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      sgroup "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S2_CTRL_CAL_REQUEST"
      sgroup "S2_CTRL_CAL_REQUEST (at 0x117e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_CTRL_CAL_CTL_1"
      sgroup "S2_CTRL_CAL_CTL_1 (at 0x117e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_CAL_CTL_2"
      sgroup "S2_CTRL_CAL_CTL_2 (at 0x117e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_MAN_CAL_VAL"
      sgroup "S2_CTRL_MAN_CAL_VAL (at 0x117e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_CAL_CTL_1_SHADOW"
      sgroup "S2_CTRL_CAL_CTL_1_SHADOW (at 0x117e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CAL_CTL_2_SHADOW"
      sgroup "S2_CTRL_CAL_CTL_2_SHADOW (at 0x117e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0, 1"
    tree.end
    tree "S2_CTRL_REFDAC_CAL_VAL"
      sgroup "S2_CTRL_REFDAC_CAL_VAL (at 0x117ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S2_CTRL_VDIP_CAL_VAL"
      sgroup "S2_CTRL_VDIP_CAL_VAL (at 0x117eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      sgroup "S2_CTRL_IDAC_CAL_VAL (at 0x117ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      sgroup "S2_CTRL_CORR_CAL_VAL (at 0x117ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      sgroup "S2_CTRL_PWM_CAL_VAL (at 0x117ee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      sgroup "S2_CTRL_PFM_CAL_VAL (at 0x117ef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      sgroup "S2_CTRL_TRIM_NUM (at 0x117f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      sgroup "S2_CTRL_REFDAC_TRIM (at 0x117f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      sgroup "S2_CTRL_RAMP_TRIM (at 0x117f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      sgroup "S2_FREQ_REVISION1 (at 0x11900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      sgroup "S2_FREQ_REVISION2 (at 0x11901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      sgroup "S2_FREQ_PERPH_TYPE (at 0x11904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      sgroup "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      sgroup "S2_FREQ_CLK_ENABLE (at 0x11946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      sgroup "S2_FREQ_CLK_DIV (at 0x11950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      sgroup "S2_FREQ_CLK_PHASE (at 0x11951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      sgroup "S2_FREQ_GANG_CTL1 (at 0x119c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      sgroup "S2_FREQ_GANG_CTL2 (at 0x119c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      sgroup "S2_FREQ_SEC_ACCESS (at 0x119d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      sgroup "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      sgroup "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      sgroup "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      sgroup "S2_FREQ_TEST1 (at 0x119e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      sgroup "S2_PS_REVISION1 (at 0x11800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      sgroup "S2_PS_REVISION2 (at 0x11801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      sgroup "S2_PS_REVISION3 (at 0x11802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      sgroup "S2_PS_REVISION4 (at 0x11803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      sgroup "S2_PS_PERPH_TYPE (at 0x11804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      sgroup "S2_PS_PERPH_SUBTYPE (at 0x11805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_STATUS_1"
      sgroup "S2_PS_STATUS_1 (at 0x11808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_OFFSET_CAL_FAULT                  = " "0 (SAMPL_OFFSET_CAL_FAULT_FALSE),1 (SAMPL_OFFSET_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S2_PS_STATUS_2"
      sgroup "S2_PS_STATUS_2 (at 0x11809)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      sgroup "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      sgroup "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_MODE_CTL"
      sgroup "S2_PS_MODE_CTL (at 0x11845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_PS_FREQ_CTL"
      sgroup "S2_PS_FREQ_CTL (at 0x11850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      sgroup "S2_PS_MULTIPHASE_CTL (at 0x11851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_PS_PHASE_CTL"
      sgroup "S2_PS_PHASE_CTL (at 0x11852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_PS_PHASE_ID"
      sgroup "S2_PS_PHASE_ID (at 0x11853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_PS_PHASE_CNT_MAX"
      sgroup "S2_PS_PHASE_CNT_MAX (at 0x11854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      sgroup "S2_PS_PWM_CL_CTL (at 0x11860)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      sgroup "S2_PS_LPM_CL_CTL (at 0x11861)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S2_PS_AUTO_CTL_1"
      sgroup "S2_PS_AUTO_CTL_1 (at 0x11862)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S2_PS_LPM_ADC_VAL"
      sgroup "S2_PS_LPM_ADC_VAL (at 0x11863)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S2_PS_LPM_ADC_CTL"
      sgroup "S2_PS_LPM_ADC_CTL (at 0x11864)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0 (LPM_REC_FILT_2),1 (LPM_REC_FILT_4),2 (LPM_REC_FILT_8),3 (LPM_REC_FILT_16)"
    tree.end
    tree "S2_PS_ACTIVITY_DETECT"
      sgroup "S2_PS_ACTIVITY_DETECT (at 0x11865)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0 (ACT_LO_2_CYC),1 (ACT_LO_4_CYC),2 (ACT_LO_8_CYC),3 (ACT_LO_16_CYC)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0 (ACT_HI_1_CYC),1 (ACT_HI_2_CYC),2 (ACT_HI_3_CYC),3 (ACT_HI_4_CYC)"
    tree.end
    tree "S2_PS_LPM_CFG"
      sgroup "S2_PS_LPM_CFG (at 0x11868)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      sgroup "S2_PS_FSM_MINON_CFG (at 0x11870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      sgroup "S2_PS_ZX_CAL_CFG (at 0x11873)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      sgroup "S2_PS_NONOVLAP_CFG (at 0x11874)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_PEAK_SAMPLE                          = " "0 (SAMPLE_AVG_SEL),1 (SAMPLE_PEAK_SEL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S2_PS_ADC_FRONT_CFG"
      sgroup "S2_PS_ADC_FRONT_CFG (at 0x11875)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_P0_LUT_IN"
      sgroup "S2_PS_P0_LUT_IN (at 0x11878)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S2_PS_MPH_STROBE"
      sgroup "S2_PS_MPH_STROBE (at 0x11879)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_PS_LUT_OUT"
      sgroup "S2_PS_LUT_OUT (at 0x1187a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_OUT"
      sgroup "S2_PS_ADC_OUT (at 0x1187b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_FRC"
      sgroup "S2_PS_ADC_FRC (at 0x1187c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_MP_CORR_DFT"
      sgroup "S2_PS_MP_CORR_DFT (at 0x1187d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S2_PS_DAC_DATA"
      sgroup "S2_PS_DAC_DATA (at 0x1187e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S2_PS_DAC_FRC"
      sgroup "S2_PS_DAC_FRC (at 0x1187f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_0"
      sgroup "S2_PS_LUT_DAC_PT_0 (at 0x11880)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_1"
      sgroup "S2_PS_LUT_DAC_PT_1 (at 0x11881)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_2"
      sgroup "S2_PS_LUT_DAC_PT_2 (at 0x11882)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_3"
      sgroup "S2_PS_LUT_DAC_PT_3 (at 0x11883)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_1"
      sgroup "S2_PS_LUT_ADC_PT_1 (at 0x11887)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_2"
      sgroup "S2_PS_LUT_ADC_PT_2 (at 0x11888)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_3"
      sgroup "S2_PS_LUT_ADC_PT_3 (at 0x11889)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_0"
      sgroup "S2_PS_LUT_SLOPE_HI_0 (at 0x1188c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80188c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x188c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_0"
      sgroup "S2_PS_LUT_SLOPE_LO_0 (at 0x1188d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80188d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x188d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_1"
      sgroup "S2_PS_LUT_SLOPE_HI_1 (at 0x1188e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80188e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x188e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_1"
      sgroup "S2_PS_LUT_SLOPE_LO_1 (at 0x1188f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80188f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x188f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_2"
      sgroup "S2_PS_LUT_SLOPE_HI_2 (at 0x11890)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_2"
      sgroup "S2_PS_LUT_SLOPE_LO_2 (at 0x11891)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      sgroup "S2_PS_MPHASE_PI_CFG1 (at 0x11896)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      sgroup "S2_PS_MPHASE_PI_CFG4 (at 0x11897)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PHASE_CNT"
      sgroup "S2_PS_MPHASE_PHASE_CNT (at 0x11898)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PHASE_CNT_FILT_NPM                       = " "0 (PH_CNT_FILT_NPM_2P5US),1 (PH_CNT_FILT_NPM_10US),2 (PH_CNT_FILT_NPM_40US),3 (PH_CNT_FILT_NPM_160US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT_LPM                       = " "0 (PH_CNT_FILT_LPM_2P5US),1 (PH_CNT_FILT_LPM_10US),2 (PH_CNT_FILT_LPM_40US),3 (PH_CNT_FILT_LPM_160US)"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_1"
      sgroup "S2_PS_EN_OPTIONS_DFT_1 (at 0x118a8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_2"
      sgroup "S2_PS_EN_OPTIONS_DFT_2 (at 0x118a9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S2_PS_ZX_ADAPT_CTL"
      sgroup "S2_PS_ZX_ADAPT_CTL (at 0x118aa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S2_PS_ZX_ADAPT_VAL"
      sgroup "S2_PS_ZX_ADAPT_VAL (at 0x118ab)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S2_PS_ADC_CLK_CTL"
      sgroup "S2_PS_ADC_CLK_CTL (at 0x118ac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_PULSE_SKIP_CLK_EN                    = " "0 (ADC_PULS_SKIP_CLK_DISABL),1 (ADC_PULS_SKIP_CLK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S2_PS_ATEST12"
      sgroup "S2_PS_ATEST12 (at 0x118b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S2_PS_ATEST34"
      sgroup "S2_PS_ATEST34 (at 0x118b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S2_PS_DTEST12"
      sgroup "S2_PS_DTEST12 (at 0x118b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_DTEST_ADC_2),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_DTEST_ADC_1),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S2_PS_DTEST43"
      sgroup "S2_PS_DTEST43 (at 0x118b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_DTEST_ADC_3),2 (DTEST3_DTEST_ADC_4),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S2_PS_GANG_CTL1"
      sgroup "S2_PS_GANG_CTL1 (at 0x118c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      sgroup "S2_PS_GANG_CTL2 (at 0x118c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      sgroup "S2_PS_SEC_ACCESS (at 0x118d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      sgroup "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      sgroup "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      sgroup "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_CAL_REQUEST"
      sgroup "S2_PS_CAL_REQUEST (at 0x118e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_PS_MAN_CAL_VAL"
      sgroup "S2_PS_MAN_CAL_VAL (at 0x118e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_PS_REPLICA_CFG"
      sgroup "S2_PS_REPLICA_CFG (at 0x118e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_1"
      sgroup "S2_PS_CAL_CTL_1 (at 0x118e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_USE_SAMPLE_OFFSET_TRIM),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_USE_ZX_TRIM_2),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_2"
      sgroup "S2_PS_CAL_CTL_2 (at 0x118e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0 (SAMPL_OFFSET_CAL_MISSON_MODE),1 (SAMPL_OFFSET_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_SAMPLE_OFFSET_CAL_VAL"
      sgroup "S2_PS_SAMPLE_OFFSET_CAL_VAL (at 0x118e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_CAL_VAL                    = "
    tree.end
    tree "S2_PS_REPLICA_CAL_VAL"
      sgroup "S2_PS_REPLICA_CAL_VAL (at 0x118ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S2_PS_DACMID_BUF_CAL_VAL"
      sgroup "S2_PS_DACMID_BUF_CAL_VAL (at 0x118ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S2_PS_FRONT_BUF_CAL_VAL"
      sgroup "S2_PS_FRONT_BUF_CAL_VAL (at 0x118ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S2_PS_CL_CAL_VAL"
      sgroup "S2_PS_CL_CAL_VAL (at 0x118ee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ZX_CAL_VAL"
      sgroup "S2_PS_ZX_CAL_VAL (at 0x118ef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_TRIM_NUM"
      sgroup "S2_PS_TRIM_NUM (at 0x118f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      sgroup "S2_PS_ZX_TRIM (at 0x118f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      sgroup "S2_PS_CL_TRIM (at 0x118f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S2_PS_REPLICA_TRIM"
      sgroup "S2_PS_REPLICA_TRIM (at 0x118f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
    tree "S2_PS_SAMPLE_OFFSET_TRIM"
      sgroup "S2_PS_SAMPLE_OFFSET_TRIM (at 0x118f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      sgroup "S4_CTRL_REVISION1 (at 0x11d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      sgroup "S4_CTRL_REVISION2 (at 0x11d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      sgroup "S4_CTRL_REVISION3 (at 0x11d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      sgroup "S4_CTRL_REVISION4 (at 0x11d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      sgroup "S4_CTRL_PERPH_TYPE (at 0x11d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      sgroup "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS_1"
      sgroup "S4_CTRL_STATUS_1 (at 0x11d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S4_CTRL_STATUS_2"
      sgroup "S4_CTRL_STATUS_2 (at 0x11d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S4_CTRL_STATUS_3"
      sgroup "S4_CTRL_STATUS_3 (at 0x11d0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S4_CTRL_STATUS_4"
      sgroup "S4_CTRL_STATUS_4 (at 0x11d0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S4_CTRL_STATUS_5"
      sgroup "S4_CTRL_STATUS_5 (at 0x11d0c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      sgroup "S4_CTRL_INT_RT_STS (at 0x11d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      sgroup "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      sgroup "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      sgroup "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      sgroup "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      sgroup "S4_CTRL_INT_EN_SET (at 0x11d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      sgroup "S4_CTRL_INT_EN_CLR (at 0x11d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      sgroup "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      sgroup "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      sgroup "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      sgroup "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      sgroup "S4_CTRL_VOLTAGE_CTL1 (at 0x11d40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      sgroup "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_CTRL_VSET_VALID"
      sgroup "S4_CTRL_VSET_VALID (at 0x11d42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S4_CTRL_MPPFM_VOFFSET"
      sgroup "S4_CTRL_MPPFM_VOFFSET (at 0x11d44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      sgroup "S4_CTRL_MODE_CTL (at 0x11d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      sgroup "S4_CTRL_EN_CTL (at 0x11d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      sgroup "S4_CTRL_PD_CTL (at 0x11d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S4_CTRL_FREQ_CTL"
      sgroup "S4_CTRL_FREQ_CTL (at 0x11d50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_CTRL_MULTIPHASE_CTL"
      sgroup "S4_CTRL_MULTIPHASE_CTL (at 0x11d51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S4_CTRL_PHASE_CTL"
      sgroup "S4_CTRL_PHASE_CTL (at 0x11d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S4_CTRL_PHASE_ID"
      sgroup "S4_CTRL_PHASE_ID (at 0x11d53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S4_CTRL_PHASE_CNT_MAX"
      sgroup "S4_CTRL_PHASE_CNT_MAX (at 0x11d54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S4_CTRL_PH_READY"
      sgroup "S4_CTRL_PH_READY (at 0x11d55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S4_CTRL_SS_CTL"
      sgroup "S4_CTRL_SS_CTL (at 0x11d60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S4_CTRL_VS_CTL"
      sgroup "S4_CTRL_VS_CTL (at 0x11d61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S4_CTRL_CORR_CFG"
      sgroup "S4_CTRL_CORR_CFG (at 0x11d62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S4_CTRL_RAMP_CFG"
      sgroup "S4_CTRL_RAMP_CFG (at 0x11d63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S4_CTRL_COMPENS_CFG"
      sgroup "S4_CTRL_COMPENS_CFG (at 0x11d64)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_100KHZ),1 (BP_LPF_280KHZ),2 (BP_LPF_460KHZ),3 (BP_LPF_640KHZ),4 (BP_LPF_780KHZ),5 (BP_LPF_990KHZ),6 (BP_LPF_1130KHZ),7 (BP_LPF_1340KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_100KHZ),1 (BP_LPF2_280KHZ),2 (BP_LPF2_460KHZ),3 (BP_LPF2_640KHZ),4 (BP_LPF2_780KHZ),5 (BP_LPF2_990KHZ),6 (BP_LPF2_1130KHZ),7 (BP_LPF2_1340KHZ)"
    tree.end
    tree "S4_CTRL_CFG_VREG_MON"
      sgroup "S4_CTRL_CFG_VREG_MON (at 0x11d65)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S4_CTRL_CFG_VREG_OCP"
      sgroup "S4_CTRL_CFG_VREG_OCP (at 0x11d66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_CFG_PFM_COMP"
      sgroup "S4_CTRL_CFG_PFM_COMP (at 0x11d67)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S4_CTRL_UL_LL_CTL"
      sgroup "S4_CTRL_UL_LL_CTL (at 0x11d68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S4_CTRL_VSET_ULS"
      sgroup "S4_CTRL_VSET_ULS (at 0x11d69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S4_CTRL_ULS_VALID"
      sgroup "S4_CTRL_ULS_VALID (at 0x11d6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S4_CTRL_VSET_LLS"
      sgroup "S4_CTRL_VSET_LLS (at 0x11d6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S4_CTRL_LLS_VALID"
      sgroup "S4_CTRL_LLS_VALID (at 0x11d6c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S4_CTRL_GPL_HI"
      sgroup "S4_CTRL_GPL_HI (at 0x11d6d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S4_CTRL_GPL_LO"
      sgroup "S4_CTRL_GPL_LO (at 0x11d6e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S4_CTRL_FB_FILT_CFG"
      sgroup "S4_CTRL_FB_FILT_CFG (at 0x11d6f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_0P47MHZ),1 (FBLP_CORNER_1P5MHZ),2 (FBLP_CORNER_6MHZ),3 (FBLP_CORNER_20MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S4_CTRL_VDIP_CFG"
      sgroup "S4_CTRL_VDIP_CFG (at 0x11d71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_BURST_ENABLED_1),3 (VDIP_BURST_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S4_CTRL_MPH_STROBE"
      sgroup "S4_CTRL_MPH_STROBE (at 0x11d79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S4_CTRL_MODE_FSM_MASK"
      sgroup "S4_CTRL_MODE_FSM_MASK (at 0x11da0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S4_CTRL_MODE_FSM_WAITS_1"
      sgroup "S4_CTRL_MODE_FSM_WAITS_1 (at 0x11da1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S4_CTRL_MODE_FSM_WAIT_2"
      sgroup "S4_CTRL_MODE_FSM_WAIT_2 (at 0x11da2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S4_CTRL_GATE_DRV_MUX"
      sgroup "S4_CTRL_GATE_DRV_MUX (at 0x11da3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S4_CTRL_CORR_DUTY_MUX"
      sgroup "S4_CTRL_CORR_DUTY_MUX (at 0x11da4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT_1"
      sgroup "S4_CTRL_EN_OPTIONS_DFT_1 (at 0x11da5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT_2"
      sgroup "S4_CTRL_EN_OPTIONS_DFT_2 (at 0x11da6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S4_CTRL_MPHASE_IDAC"
      sgroup "S4_CTRL_MPHASE_IDAC (at 0x11da7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT_1_SHADOW"
      sgroup "S4_CTRL_EN_OPTIONS_DFT_1_SHADOW (at 0x11da8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT_2_SHADOW"
      sgroup "S4_CTRL_EN_OPTIONS_DFT_2_SHADOW (at 0x11da9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801da90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1da90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S4_CTRL_ZX_ADAPT_CTL_SHADOW"
      sgroup "S4_CTRL_ZX_ADAPT_CTL_SHADOW (at 0x11daa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801daa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1daa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_ANTI_ESL_CFG_1"
      sgroup "S4_CTRL_ANTI_ESL_CFG_1 (at 0x11dac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DUTY_FB_SEL_CORR                         = " "0 (DUTY_FB_CORR_PWM),1 (DUTY_FB_CORR_AFSM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DUTY_FB_SEL_COMPENS                      = " "0 (DUTY_FB_COMPENS_PWM),1 (DUTY_FB_COMPENS_AFSM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DUTY_FB_SEL_ANTI_ESL                     = " "0 (DUTY_FB_ANTIESL_PWM),1 (DUTY_FB_ANTIESL_AFSM)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_UNLATCHED_2),2 (GRDV_FULL_LATCHED),3 (GDRV_HALF_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_ANTI_ESL_CFG_2"
      sgroup "S4_CTRL_ANTI_ESL_CFG_2 (at 0x11dad)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_2                                  = " "0 (SPARE_2_LO),1 (SPARE_2_HI)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_1                                  = " "0 (LPM_IDAC_REF_DISABL),1 (LPM_IDAC_REF_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_0                                  = " "0 (SPARE_0_LO),1 (SPARE_0_HI)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ESL_PULSE_RESET_EN                       = " "0 (ESL_PULSE_RST_DISABL),1 (ESL_PULSE_RST_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S4_CTRL_CFG_ATEST1"
      sgroup "S4_CTRL_CFG_ATEST1 (at 0x11db0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S4_CTRL_CFG_ATEST2"
      sgroup "S4_CTRL_CFG_ATEST2 (at 0x11db1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S4_CTRL_CFG_ATEST3"
      sgroup "S4_CTRL_CFG_ATEST3 (at 0x11db2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S4_CTRL_CFG_ATEST4"
      sgroup "S4_CTRL_CFG_ATEST4 (at 0x11db3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S4_CTRL_CFG_DTEST1"
      sgroup "S4_CTRL_CFG_DTEST1 (at 0x11db4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S4_CTRL_CFG_DTEST2"
      sgroup "S4_CTRL_CFG_DTEST2 (at 0x11db5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S4_CTRL_CFG_DTEST3"
      sgroup "S4_CTRL_CFG_DTEST3 (at 0x11db6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S4_CTRL_CFG_DTEST4"
      sgroup "S4_CTRL_CFG_DTEST4 (at 0x11db7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S4_CTRL_GANG_CTL1"
      sgroup "S4_CTRL_GANG_CTL1 (at 0x11dc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_CTRL_GANG_CTL2"
      sgroup "S4_CTRL_GANG_CTL2 (at 0x11dc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      sgroup "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      sgroup "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      sgroup "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      sgroup "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      sgroup "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      sgroup "S4_CTRL_INT_TEST1 (at 0x11de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      sgroup "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S4_CTRL_CAL_REQUEST"
      sgroup "S4_CTRL_CAL_REQUEST (at 0x11de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S4_CTRL_CAL_CTL_1"
      sgroup "S4_CTRL_CAL_CTL_1 (at 0x11de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S4_CTRL_CAL_CTL_2"
      sgroup "S4_CTRL_CAL_CTL_2 (at 0x11de4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S4_CTRL_MAN_CAL_VAL"
      sgroup "S4_CTRL_MAN_CAL_VAL (at 0x11de5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_CAL_CTL_1_SHADOW"
      sgroup "S4_CTRL_CAL_CTL_1_SHADOW (at 0x11de7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CAL_CTL_2_SHADOW"
      sgroup "S4_CTRL_CAL_CTL_2_SHADOW (at 0x11de8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0, 1"
    tree.end
    tree "S4_CTRL_REFDAC_CAL_VAL"
      sgroup "S4_CTRL_REFDAC_CAL_VAL (at 0x11dea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S4_CTRL_VDIP_CAL_VAL"
      sgroup "S4_CTRL_VDIP_CAL_VAL (at 0x11deb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801deb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1deb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_IDAC_CAL_VAL"
      sgroup "S4_CTRL_IDAC_CAL_VAL (at 0x11dec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_CORR_CAL_VAL"
      sgroup "S4_CTRL_CORR_CAL_VAL (at 0x11ded)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ded0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ded0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_PWM_CAL_VAL"
      sgroup "S4_CTRL_PWM_CAL_VAL (at 0x11dee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_PFM_CAL_VAL"
      sgroup "S4_CTRL_PFM_CAL_VAL (at 0x11def)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801def0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1def0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      sgroup "S4_CTRL_TRIM_NUM (at 0x11df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_CTRL_REFDAC_TRIM"
      sgroup "S4_CTRL_REFDAC_TRIM (at 0x11df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S4_CTRL_RAMP_TRIM"
      sgroup "S4_CTRL_RAMP_TRIM (at 0x11df2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      sgroup "S4_FREQ_REVISION1 (at 0x11f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      sgroup "S4_FREQ_REVISION2 (at 0x11f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      sgroup "S4_FREQ_PERPH_TYPE (at 0x11f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      sgroup "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      sgroup "S4_FREQ_CLK_ENABLE (at 0x11f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      sgroup "S4_FREQ_CLK_DIV (at 0x11f50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      sgroup "S4_FREQ_CLK_PHASE (at 0x11f51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      sgroup "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      sgroup "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      sgroup "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      sgroup "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      sgroup "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      sgroup "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      sgroup "S4_FREQ_TEST1 (at 0x11fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      sgroup "S4_PS_REVISION1 (at 0x11e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      sgroup "S4_PS_REVISION2 (at 0x11e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      sgroup "S4_PS_REVISION3 (at 0x11e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      sgroup "S4_PS_REVISION4 (at 0x11e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      sgroup "S4_PS_PERPH_TYPE (at 0x11e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      sgroup "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_STATUS_1"
      sgroup "S4_PS_STATUS_1 (at 0x11e08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_OFFSET_CAL_FAULT                  = " "0 (SAMPL_OFFSET_CAL_FAULT_FALSE),1 (SAMPL_OFFSET_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S4_PS_STATUS_2"
      sgroup "S4_PS_STATUS_2 (at 0x11e09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S4_PS_VOLTAGE_CTL1"
      sgroup "S4_PS_VOLTAGE_CTL1 (at 0x11e40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S4_PS_VOLTAGE_CTL2"
      sgroup "S4_PS_VOLTAGE_CTL2 (at 0x11e41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_PS_MODE_CTL"
      sgroup "S4_PS_MODE_CTL (at 0x11e45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S4_PS_FREQ_CTL"
      sgroup "S4_PS_FREQ_CTL (at 0x11e50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_PS_MULTIPHASE_CTL"
      sgroup "S4_PS_MULTIPHASE_CTL (at 0x11e51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S4_PS_PHASE_CTL"
      sgroup "S4_PS_PHASE_CTL (at 0x11e52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S4_PS_PHASE_ID"
      sgroup "S4_PS_PHASE_ID (at 0x11e53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S4_PS_PHASE_CNT_MAX"
      sgroup "S4_PS_PHASE_CNT_MAX (at 0x11e54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S4_PS_PWM_CL_CTL"
      sgroup "S4_PS_PWM_CL_CTL (at 0x11e60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S4_PS_LPM_CL_CTL"
      sgroup "S4_PS_LPM_CL_CTL (at 0x11e61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S4_PS_AUTO_CTL_1"
      sgroup "S4_PS_AUTO_CTL_1 (at 0x11e62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S4_PS_LPM_ADC_VAL"
      sgroup "S4_PS_LPM_ADC_VAL (at 0x11e63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S4_PS_LPM_ADC_CTL"
      sgroup "S4_PS_LPM_ADC_CTL (at 0x11e64)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0 (LPM_REC_FILT_2),1 (LPM_REC_FILT_4),2 (LPM_REC_FILT_8),3 (LPM_REC_FILT_16)"
    tree.end
    tree "S4_PS_ACTIVITY_DETECT"
      sgroup "S4_PS_ACTIVITY_DETECT (at 0x11e65)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0 (ACT_LO_2_CYC),1 (ACT_LO_4_CYC),2 (ACT_LO_8_CYC),3 (ACT_LO_16_CYC)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0 (ACT_HI_1_CYC),1 (ACT_HI_2_CYC),2 (ACT_HI_3_CYC),3 (ACT_HI_4_CYC)"
    tree.end
    tree "S4_PS_LPM_CFG"
      sgroup "S4_PS_LPM_CFG (at 0x11e68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S4_PS_FSM_MINON_CFG"
      sgroup "S4_PS_FSM_MINON_CFG (at 0x11e70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S4_PS_ZX_CAL_CFG"
      sgroup "S4_PS_ZX_CAL_CFG (at 0x11e73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S4_PS_NONOVLAP_CFG"
      sgroup "S4_PS_NONOVLAP_CFG (at 0x11e74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_PEAK_SAMPLE                          = " "0 (SAMPLE_AVG_SEL),1 (SAMPLE_PEAK_SEL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S4_PS_ADC_FRONT_CFG"
      sgroup "S4_PS_ADC_FRONT_CFG (at 0x11e75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_P0_LUT_IN"
      sgroup "S4_PS_P0_LUT_IN (at 0x11e78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S4_PS_MPH_STROBE"
      sgroup "S4_PS_MPH_STROBE (at 0x11e79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S4_PS_LUT_OUT"
      sgroup "S4_PS_LUT_OUT (at 0x11e7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S4_PS_ADC_OUT"
      sgroup "S4_PS_ADC_OUT (at 0x11e7b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S4_PS_ADC_FRC"
      sgroup "S4_PS_ADC_FRC (at 0x11e7c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S4_PS_MP_CORR_DFT"
      sgroup "S4_PS_MP_CORR_DFT (at 0x11e7d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S4_PS_DAC_DATA"
      sgroup "S4_PS_DAC_DATA (at 0x11e7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S4_PS_DAC_FRC"
      sgroup "S4_PS_DAC_FRC (at 0x11e7f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S4_PS_LUT_DAC_PT_0"
      sgroup "S4_PS_LUT_DAC_PT_0 (at 0x11e80)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S4_PS_LUT_DAC_PT_1"
      sgroup "S4_PS_LUT_DAC_PT_1 (at 0x11e81)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S4_PS_LUT_DAC_PT_2"
      sgroup "S4_PS_LUT_DAC_PT_2 (at 0x11e82)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S4_PS_LUT_DAC_PT_3"
      sgroup "S4_PS_LUT_DAC_PT_3 (at 0x11e83)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S4_PS_LUT_ADC_PT_1"
      sgroup "S4_PS_LUT_ADC_PT_1 (at 0x11e87)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S4_PS_LUT_ADC_PT_2"
      sgroup "S4_PS_LUT_ADC_PT_2 (at 0x11e88)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S4_PS_LUT_ADC_PT_3"
      sgroup "S4_PS_LUT_ADC_PT_3 (at 0x11e89)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S4_PS_LUT_SLOPE_HI_0"
      sgroup "S4_PS_LUT_SLOPE_HI_0 (at 0x11e8c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e8c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e8c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S4_PS_LUT_SLOPE_LO_0"
      sgroup "S4_PS_LUT_SLOPE_LO_0 (at 0x11e8d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e8d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e8d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S4_PS_LUT_SLOPE_HI_1"
      sgroup "S4_PS_LUT_SLOPE_HI_1 (at 0x11e8e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e8e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e8e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S4_PS_LUT_SLOPE_LO_1"
      sgroup "S4_PS_LUT_SLOPE_LO_1 (at 0x11e8f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e8f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e8f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S4_PS_LUT_SLOPE_HI_2"
      sgroup "S4_PS_LUT_SLOPE_HI_2 (at 0x11e90)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S4_PS_LUT_SLOPE_LO_2"
      sgroup "S4_PS_LUT_SLOPE_LO_2 (at 0x11e91)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG1"
      sgroup "S4_PS_MPHASE_PI_CFG1 (at 0x11e96)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG4"
      sgroup "S4_PS_MPHASE_PI_CFG4 (at 0x11e97)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S4_PS_MPHASE_PHASE_CNT"
      sgroup "S4_PS_MPHASE_PHASE_CNT (at 0x11e98)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PHASE_CNT_FILT_NPM                       = " "0 (PH_CNT_FILT_NPM_2P5US),1 (PH_CNT_FILT_NPM_10US),2 (PH_CNT_FILT_NPM_40US),3 (PH_CNT_FILT_NPM_160US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT_LPM                       = " "0 (PH_CNT_FILT_LPM_2P5US),1 (PH_CNT_FILT_LPM_10US),2 (PH_CNT_FILT_LPM_40US),3 (PH_CNT_FILT_LPM_160US)"
    tree.end
    tree "S4_PS_EN_OPTIONS_DFT_1"
      sgroup "S4_PS_EN_OPTIONS_DFT_1 (at 0x11ea8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ea80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ea80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S4_PS_EN_OPTIONS_DFT_2"
      sgroup "S4_PS_EN_OPTIONS_DFT_2 (at 0x11ea9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ea90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ea90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S4_PS_ZX_ADAPT_CTL"
      sgroup "S4_PS_ZX_ADAPT_CTL (at 0x11eaa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eaa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eaa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S4_PS_ZX_ADAPT_VAL"
      sgroup "S4_PS_ZX_ADAPT_VAL (at 0x11eab)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S4_PS_ADC_CLK_CTL"
      sgroup "S4_PS_ADC_CLK_CTL (at 0x11eac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_PULSE_SKIP_CLK_EN                    = " "0 (ADC_PULS_SKIP_CLK_DISABL),1 (ADC_PULS_SKIP_CLK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S4_PS_ATEST12"
      sgroup "S4_PS_ATEST12 (at 0x11eb0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eb00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eb00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S4_PS_ATEST34"
      sgroup "S4_PS_ATEST34 (at 0x11eb1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eb10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eb10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S4_PS_DTEST12"
      sgroup "S4_PS_DTEST12 (at 0x11eb2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eb20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eb20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_DTEST_ADC_2),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_DTEST_ADC_1),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S4_PS_DTEST43"
      sgroup "S4_PS_DTEST43 (at 0x11eb3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eb30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eb30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_DTEST_ADC_3),2 (DTEST3_DTEST_ADC_4),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S4_PS_GANG_CTL1"
      sgroup "S4_PS_GANG_CTL1 (at 0x11ec0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ec00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ec00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_PS_GANG_CTL2"
      sgroup "S4_PS_GANG_CTL2 (at 0x11ec1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ec10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ec10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      sgroup "S4_PS_SEC_ACCESS (at 0x11ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      sgroup "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      sgroup "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      sgroup "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_PS_CAL_REQUEST"
      sgroup "S4_PS_CAL_REQUEST (at 0x11ee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S4_PS_MAN_CAL_VAL"
      sgroup "S4_PS_MAN_CAL_VAL (at 0x11ee5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S4_PS_REPLICA_CFG"
      sgroup "S4_PS_REPLICA_CFG (at 0x11ee6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S4_PS_CAL_CTL_1"
      sgroup "S4_PS_CAL_CTL_1 (at 0x11ee7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_USE_SAMPLE_OFFSET_TRIM),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_USE_ZX_TRIM_2),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S4_PS_CAL_CTL_2"
      sgroup "S4_PS_CAL_CTL_2 (at 0x11ee8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0 (SAMPL_OFFSET_CAL_MISSON_MODE),1 (SAMPL_OFFSET_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S4_PS_SAMPLE_OFFSET_CAL_VAL"
      sgroup "S4_PS_SAMPLE_OFFSET_CAL_VAL (at 0x11ee9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_CAL_VAL                    = "
    tree.end
    tree "S4_PS_REPLICA_CAL_VAL"
      sgroup "S4_PS_REPLICA_CAL_VAL (at 0x11eea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S4_PS_DACMID_BUF_CAL_VAL"
      sgroup "S4_PS_DACMID_BUF_CAL_VAL (at 0x11eec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S4_PS_FRONT_BUF_CAL_VAL"
      sgroup "S4_PS_FRONT_BUF_CAL_VAL (at 0x11eed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S4_PS_CL_CAL_VAL"
      sgroup "S4_PS_CL_CAL_VAL (at 0x11eee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S4_PS_ZX_CAL_VAL"
      sgroup "S4_PS_ZX_CAL_VAL (at 0x11eef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S4_PS_TRIM_NUM"
      sgroup "S4_PS_TRIM_NUM (at 0x11ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_PS_ZX_TRIM"
      sgroup "S4_PS_ZX_TRIM (at 0x11ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S4_PS_CL_TRIM"
      sgroup "S4_PS_CL_TRIM (at 0x11ef2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S4_PS_REPLICA_TRIM"
      sgroup "S4_PS_REPLICA_TRIM (at 0x11ef3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
    tree "S4_PS_SAMPLE_OFFSET_TRIM"
      sgroup "S4_PS_SAMPLE_OFFSET_TRIM (at 0x11ef4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      sgroup "S5_CTRL_REVISION1 (at 0x12000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      sgroup "S5_CTRL_REVISION2 (at 0x12001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      sgroup "S5_CTRL_REVISION3 (at 0x12002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      sgroup "S5_CTRL_REVISION4 (at 0x12003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      sgroup "S5_CTRL_PERPH_TYPE (at 0x12004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      sgroup "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS_1"
      sgroup "S5_CTRL_STATUS_1 (at 0x12008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S5_CTRL_STATUS_2"
      sgroup "S5_CTRL_STATUS_2 (at 0x12009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S5_CTRL_STATUS_3"
      sgroup "S5_CTRL_STATUS_3 (at 0x1200a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S5_CTRL_STATUS_4"
      sgroup "S5_CTRL_STATUS_4 (at 0x1200b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S5_CTRL_STATUS_5"
      sgroup "S5_CTRL_STATUS_5 (at 0x1200c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      sgroup "S5_CTRL_INT_RT_STS (at 0x12010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      sgroup "S5_CTRL_INT_SET_TYPE (at 0x12011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      sgroup "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      sgroup "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      sgroup "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      sgroup "S5_CTRL_INT_EN_SET (at 0x12015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      sgroup "S5_CTRL_INT_EN_CLR (at 0x12016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      sgroup "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      sgroup "S5_CTRL_INT_PENDING_STS (at 0x12019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      sgroup "S5_CTRL_INT_MID_SEL (at 0x1201a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      sgroup "S5_CTRL_INT_PRIORITY (at 0x1201b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      sgroup "S5_CTRL_VOLTAGE_CTL1 (at 0x12040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      sgroup "S5_CTRL_VOLTAGE_CTL2 (at 0x12041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_CTRL_VSET_VALID"
      sgroup "S5_CTRL_VSET_VALID (at 0x12042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S5_CTRL_MPPFM_VOFFSET"
      sgroup "S5_CTRL_MPPFM_VOFFSET (at 0x12044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      sgroup "S5_CTRL_MODE_CTL (at 0x12045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S5_CTRL_EN_CTL"
      sgroup "S5_CTRL_EN_CTL (at 0x12046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S5_CTRL_PD_CTL"
      sgroup "S5_CTRL_PD_CTL (at 0x12048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S5_CTRL_FREQ_CTL"
      sgroup "S5_CTRL_FREQ_CTL (at 0x12050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_CTRL_MULTIPHASE_CTL"
      sgroup "S5_CTRL_MULTIPHASE_CTL (at 0x12051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S5_CTRL_PHASE_CTL"
      sgroup "S5_CTRL_PHASE_CTL (at 0x12052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S5_CTRL_PHASE_ID"
      sgroup "S5_CTRL_PHASE_ID (at 0x12053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S5_CTRL_PHASE_CNT_MAX"
      sgroup "S5_CTRL_PHASE_CNT_MAX (at 0x12054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S5_CTRL_PH_READY"
      sgroup "S5_CTRL_PH_READY (at 0x12055)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S5_CTRL_SS_CTL"
      sgroup "S5_CTRL_SS_CTL (at 0x12060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S5_CTRL_VS_CTL"
      sgroup "S5_CTRL_VS_CTL (at 0x12061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S5_CTRL_CORR_CFG"
      sgroup "S5_CTRL_CORR_CFG (at 0x12062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S5_CTRL_RAMP_CFG"
      sgroup "S5_CTRL_RAMP_CFG (at 0x12063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S5_CTRL_COMPENS_CFG"
      sgroup "S5_CTRL_COMPENS_CFG (at 0x12064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_100KHZ),1 (BP_LPF_280KHZ),2 (BP_LPF_460KHZ),3 (BP_LPF_640KHZ),4 (BP_LPF_780KHZ),5 (BP_LPF_990KHZ),6 (BP_LPF_1130KHZ),7 (BP_LPF_1340KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_100KHZ),1 (BP_LPF2_280KHZ),2 (BP_LPF2_460KHZ),3 (BP_LPF2_640KHZ),4 (BP_LPF2_780KHZ),5 (BP_LPF2_990KHZ),6 (BP_LPF2_1130KHZ),7 (BP_LPF2_1340KHZ)"
    tree.end
    tree "S5_CTRL_CFG_VREG_MON"
      sgroup "S5_CTRL_CFG_VREG_MON (at 0x12065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S5_CTRL_CFG_VREG_OCP"
      sgroup "S5_CTRL_CFG_VREG_OCP (at 0x12066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_CFG_PFM_COMP"
      sgroup "S5_CTRL_CFG_PFM_COMP (at 0x12067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S5_CTRL_UL_LL_CTL"
      sgroup "S5_CTRL_UL_LL_CTL (at 0x12068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S5_CTRL_VSET_ULS"
      sgroup "S5_CTRL_VSET_ULS (at 0x12069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S5_CTRL_ULS_VALID"
      sgroup "S5_CTRL_ULS_VALID (at 0x1206a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S5_CTRL_VSET_LLS"
      sgroup "S5_CTRL_VSET_LLS (at 0x1206b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S5_CTRL_LLS_VALID"
      sgroup "S5_CTRL_LLS_VALID (at 0x1206c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S5_CTRL_GPL_HI"
      sgroup "S5_CTRL_GPL_HI (at 0x1206d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S5_CTRL_GPL_LO"
      sgroup "S5_CTRL_GPL_LO (at 0x1206e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S5_CTRL_FB_FILT_CFG"
      sgroup "S5_CTRL_FB_FILT_CFG (at 0x1206f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_0P47MHZ),1 (FBLP_CORNER_1P5MHZ),2 (FBLP_CORNER_6MHZ),3 (FBLP_CORNER_20MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S5_CTRL_VDIP_CFG"
      sgroup "S5_CTRL_VDIP_CFG (at 0x12071)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_BURST_ENABLED_1),3 (VDIP_BURST_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S5_CTRL_MPH_STROBE"
      sgroup "S5_CTRL_MPH_STROBE (at 0x12079)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S5_CTRL_MODE_FSM_MASK"
      sgroup "S5_CTRL_MODE_FSM_MASK (at 0x120a0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S5_CTRL_MODE_FSM_WAITS_1"
      sgroup "S5_CTRL_MODE_FSM_WAITS_1 (at 0x120a1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S5_CTRL_MODE_FSM_WAIT_2"
      sgroup "S5_CTRL_MODE_FSM_WAIT_2 (at 0x120a2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S5_CTRL_GATE_DRV_MUX"
      sgroup "S5_CTRL_GATE_DRV_MUX (at 0x120a3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S5_CTRL_CORR_DUTY_MUX"
      sgroup "S5_CTRL_CORR_DUTY_MUX (at 0x120a4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT_1"
      sgroup "S5_CTRL_EN_OPTIONS_DFT_1 (at 0x120a5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT_2"
      sgroup "S5_CTRL_EN_OPTIONS_DFT_2 (at 0x120a6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S5_CTRL_MPHASE_IDAC"
      sgroup "S5_CTRL_MPHASE_IDAC (at 0x120a7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT_1_SHADOW"
      sgroup "S5_CTRL_EN_OPTIONS_DFT_1_SHADOW (at 0x120a8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT_2_SHADOW"
      sgroup "S5_CTRL_EN_OPTIONS_DFT_2_SHADOW (at 0x120a9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S5_CTRL_ZX_ADAPT_CTL_SHADOW"
      sgroup "S5_CTRL_ZX_ADAPT_CTL_SHADOW (at 0x120aa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_ANTI_ESL_CFG_1"
      sgroup "S5_CTRL_ANTI_ESL_CFG_1 (at 0x120ac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DUTY_FB_SEL_CORR                         = " "0 (DUTY_FB_CORR_PWM),1 (DUTY_FB_CORR_AFSM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DUTY_FB_SEL_COMPENS                      = " "0 (DUTY_FB_COMPENS_PWM),1 (DUTY_FB_COMPENS_AFSM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DUTY_FB_SEL_ANTI_ESL                     = " "0 (DUTY_FB_ANTIESL_PWM),1 (DUTY_FB_ANTIESL_AFSM)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_UNLATCHED_2),2 (GRDV_FULL_LATCHED),3 (GDRV_HALF_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_ANTI_ESL_CFG_2"
      sgroup "S5_CTRL_ANTI_ESL_CFG_2 (at 0x120ad)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_2                                  = " "0 (SPARE_2_LO),1 (SPARE_2_HI)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_1                                  = " "0 (LPM_IDAC_REF_DISABL),1 (LPM_IDAC_REF_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_0                                  = " "0 (SPARE_0_LO),1 (SPARE_0_HI)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ESL_PULSE_RESET_EN                       = " "0 (ESL_PULSE_RST_DISABL),1 (ESL_PULSE_RST_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S5_CTRL_CFG_ATEST1"
      sgroup "S5_CTRL_CFG_ATEST1 (at 0x120b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S5_CTRL_CFG_ATEST2"
      sgroup "S5_CTRL_CFG_ATEST2 (at 0x120b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S5_CTRL_CFG_ATEST3"
      sgroup "S5_CTRL_CFG_ATEST3 (at 0x120b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S5_CTRL_CFG_ATEST4"
      sgroup "S5_CTRL_CFG_ATEST4 (at 0x120b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S5_CTRL_CFG_DTEST1"
      sgroup "S5_CTRL_CFG_DTEST1 (at 0x120b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S5_CTRL_CFG_DTEST2"
      sgroup "S5_CTRL_CFG_DTEST2 (at 0x120b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S5_CTRL_CFG_DTEST3"
      sgroup "S5_CTRL_CFG_DTEST3 (at 0x120b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S5_CTRL_CFG_DTEST4"
      sgroup "S5_CTRL_CFG_DTEST4 (at 0x120b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S5_CTRL_GANG_CTL1"
      sgroup "S5_CTRL_GANG_CTL1 (at 0x120c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_CTRL_GANG_CTL2"
      sgroup "S5_CTRL_GANG_CTL2 (at 0x120c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      sgroup "S5_CTRL_SEC_ACCESS (at 0x120d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      sgroup "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      sgroup "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      sgroup "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      sgroup "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      sgroup "S5_CTRL_INT_TEST1 (at 0x120e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      sgroup "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S5_CTRL_CAL_REQUEST"
      sgroup "S5_CTRL_CAL_REQUEST (at 0x120e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S5_CTRL_CAL_CTL_1"
      sgroup "S5_CTRL_CAL_CTL_1 (at 0x120e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S5_CTRL_CAL_CTL_2"
      sgroup "S5_CTRL_CAL_CTL_2 (at 0x120e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S5_CTRL_MAN_CAL_VAL"
      sgroup "S5_CTRL_MAN_CAL_VAL (at 0x120e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_CAL_CTL_1_SHADOW"
      sgroup "S5_CTRL_CAL_CTL_1_SHADOW (at 0x120e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CAL_CTL_2_SHADOW"
      sgroup "S5_CTRL_CAL_CTL_2_SHADOW (at 0x120e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0, 1"
    tree.end
    tree "S5_CTRL_REFDAC_CAL_VAL"
      sgroup "S5_CTRL_REFDAC_CAL_VAL (at 0x120ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S5_CTRL_VDIP_CAL_VAL"
      sgroup "S5_CTRL_VDIP_CAL_VAL (at 0x120eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_IDAC_CAL_VAL"
      sgroup "S5_CTRL_IDAC_CAL_VAL (at 0x120ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_CORR_CAL_VAL"
      sgroup "S5_CTRL_CORR_CAL_VAL (at 0x120ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_PWM_CAL_VAL"
      sgroup "S5_CTRL_PWM_CAL_VAL (at 0x120ee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_PFM_CAL_VAL"
      sgroup "S5_CTRL_PFM_CAL_VAL (at 0x120ef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      sgroup "S5_CTRL_TRIM_NUM (at 0x120f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_CTRL_REFDAC_TRIM"
      sgroup "S5_CTRL_REFDAC_TRIM (at 0x120f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S5_CTRL_RAMP_TRIM"
      sgroup "S5_CTRL_RAMP_TRIM (at 0x120f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      sgroup "S5_FREQ_REVISION1 (at 0x12200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      sgroup "S5_FREQ_REVISION2 (at 0x12201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      sgroup "S5_FREQ_PERPH_TYPE (at 0x12204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      sgroup "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      sgroup "S5_FREQ_CLK_ENABLE (at 0x12246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      sgroup "S5_FREQ_CLK_DIV (at 0x12250)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      sgroup "S5_FREQ_CLK_PHASE (at 0x12251)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      sgroup "S5_FREQ_GANG_CTL1 (at 0x122c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      sgroup "S5_FREQ_GANG_CTL2 (at 0x122c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      sgroup "S5_FREQ_SEC_ACCESS (at 0x122d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      sgroup "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      sgroup "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      sgroup "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S5_FREQ_TEST1"
      sgroup "S5_FREQ_TEST1 (at 0x122e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      sgroup "S5_PS_REVISION1 (at 0x12100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      sgroup "S5_PS_REVISION2 (at 0x12101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      sgroup "S5_PS_REVISION3 (at 0x12102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      sgroup "S5_PS_REVISION4 (at 0x12103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      sgroup "S5_PS_PERPH_TYPE (at 0x12104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      sgroup "S5_PS_PERPH_SUBTYPE (at 0x12105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_STATUS_1"
      sgroup "S5_PS_STATUS_1 (at 0x12108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_OFFSET_CAL_FAULT                  = " "0 (SAMPL_OFFSET_CAL_FAULT_FALSE),1 (SAMPL_OFFSET_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S5_PS_STATUS_2"
      sgroup "S5_PS_STATUS_2 (at 0x12109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S5_PS_VOLTAGE_CTL1"
      sgroup "S5_PS_VOLTAGE_CTL1 (at 0x12140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S5_PS_VOLTAGE_CTL2"
      sgroup "S5_PS_VOLTAGE_CTL2 (at 0x12141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_PS_MODE_CTL"
      sgroup "S5_PS_MODE_CTL (at 0x12145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S5_PS_FREQ_CTL"
      sgroup "S5_PS_FREQ_CTL (at 0x12150)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_PS_MULTIPHASE_CTL"
      sgroup "S5_PS_MULTIPHASE_CTL (at 0x12151)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S5_PS_PHASE_CTL"
      sgroup "S5_PS_PHASE_CTL (at 0x12152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S5_PS_PHASE_ID"
      sgroup "S5_PS_PHASE_ID (at 0x12153)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S5_PS_PHASE_CNT_MAX"
      sgroup "S5_PS_PHASE_CNT_MAX (at 0x12154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S5_PS_PWM_CL_CTL"
      sgroup "S5_PS_PWM_CL_CTL (at 0x12160)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S5_PS_LPM_CL_CTL"
      sgroup "S5_PS_LPM_CL_CTL (at 0x12161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S5_PS_AUTO_CTL_1"
      sgroup "S5_PS_AUTO_CTL_1 (at 0x12162)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S5_PS_LPM_ADC_VAL"
      sgroup "S5_PS_LPM_ADC_VAL (at 0x12163)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S5_PS_LPM_ADC_CTL"
      sgroup "S5_PS_LPM_ADC_CTL (at 0x12164)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0 (LPM_REC_FILT_2),1 (LPM_REC_FILT_4),2 (LPM_REC_FILT_8),3 (LPM_REC_FILT_16)"
    tree.end
    tree "S5_PS_ACTIVITY_DETECT"
      sgroup "S5_PS_ACTIVITY_DETECT (at 0x12165)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0 (ACT_LO_2_CYC),1 (ACT_LO_4_CYC),2 (ACT_LO_8_CYC),3 (ACT_LO_16_CYC)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0 (ACT_HI_1_CYC),1 (ACT_HI_2_CYC),2 (ACT_HI_3_CYC),3 (ACT_HI_4_CYC)"
    tree.end
    tree "S5_PS_LPM_CFG"
      sgroup "S5_PS_LPM_CFG (at 0x12168)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S5_PS_FSM_MINON_CFG"
      sgroup "S5_PS_FSM_MINON_CFG (at 0x12170)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S5_PS_ZX_CAL_CFG"
      sgroup "S5_PS_ZX_CAL_CFG (at 0x12173)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S5_PS_NONOVLAP_CFG"
      sgroup "S5_PS_NONOVLAP_CFG (at 0x12174)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_PEAK_SAMPLE                          = " "0 (SAMPLE_AVG_SEL),1 (SAMPLE_PEAK_SEL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S5_PS_ADC_FRONT_CFG"
      sgroup "S5_PS_ADC_FRONT_CFG (at 0x12175)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_P0_LUT_IN"
      sgroup "S5_PS_P0_LUT_IN (at 0x12178)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S5_PS_MPH_STROBE"
      sgroup "S5_PS_MPH_STROBE (at 0x12179)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S5_PS_LUT_OUT"
      sgroup "S5_PS_LUT_OUT (at 0x1217a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S5_PS_ADC_OUT"
      sgroup "S5_PS_ADC_OUT (at 0x1217b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S5_PS_ADC_FRC"
      sgroup "S5_PS_ADC_FRC (at 0x1217c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S5_PS_MP_CORR_DFT"
      sgroup "S5_PS_MP_CORR_DFT (at 0x1217d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S5_PS_DAC_DATA"
      sgroup "S5_PS_DAC_DATA (at 0x1217e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S5_PS_DAC_FRC"
      sgroup "S5_PS_DAC_FRC (at 0x1217f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S5_PS_LUT_DAC_PT_0"
      sgroup "S5_PS_LUT_DAC_PT_0 (at 0x12180)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S5_PS_LUT_DAC_PT_1"
      sgroup "S5_PS_LUT_DAC_PT_1 (at 0x12181)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S5_PS_LUT_DAC_PT_2"
      sgroup "S5_PS_LUT_DAC_PT_2 (at 0x12182)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S5_PS_LUT_DAC_PT_3"
      sgroup "S5_PS_LUT_DAC_PT_3 (at 0x12183)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S5_PS_LUT_ADC_PT_1"
      sgroup "S5_PS_LUT_ADC_PT_1 (at 0x12187)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S5_PS_LUT_ADC_PT_2"
      sgroup "S5_PS_LUT_ADC_PT_2 (at 0x12188)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S5_PS_LUT_ADC_PT_3"
      sgroup "S5_PS_LUT_ADC_PT_3 (at 0x12189)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S5_PS_LUT_SLOPE_HI_0"
      sgroup "S5_PS_LUT_SLOPE_HI_0 (at 0x1218c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80218c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x218c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S5_PS_LUT_SLOPE_LO_0"
      sgroup "S5_PS_LUT_SLOPE_LO_0 (at 0x1218d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80218d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x218d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S5_PS_LUT_SLOPE_HI_1"
      sgroup "S5_PS_LUT_SLOPE_HI_1 (at 0x1218e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80218e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x218e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S5_PS_LUT_SLOPE_LO_1"
      sgroup "S5_PS_LUT_SLOPE_LO_1 (at 0x1218f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80218f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x218f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S5_PS_LUT_SLOPE_HI_2"
      sgroup "S5_PS_LUT_SLOPE_HI_2 (at 0x12190)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S5_PS_LUT_SLOPE_LO_2"
      sgroup "S5_PS_LUT_SLOPE_LO_2 (at 0x12191)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG1"
      sgroup "S5_PS_MPHASE_PI_CFG1 (at 0x12196)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG4"
      sgroup "S5_PS_MPHASE_PI_CFG4 (at 0x12197)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S5_PS_MPHASE_PHASE_CNT"
      sgroup "S5_PS_MPHASE_PHASE_CNT (at 0x12198)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PHASE_CNT_FILT_NPM                       = " "0 (PH_CNT_FILT_NPM_2P5US),1 (PH_CNT_FILT_NPM_10US),2 (PH_CNT_FILT_NPM_40US),3 (PH_CNT_FILT_NPM_160US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT_LPM                       = " "0 (PH_CNT_FILT_LPM_2P5US),1 (PH_CNT_FILT_LPM_10US),2 (PH_CNT_FILT_LPM_40US),3 (PH_CNT_FILT_LPM_160US)"
    tree.end
    tree "S5_PS_EN_OPTIONS_DFT_1"
      sgroup "S5_PS_EN_OPTIONS_DFT_1 (at 0x121a8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S5_PS_EN_OPTIONS_DFT_2"
      sgroup "S5_PS_EN_OPTIONS_DFT_2 (at 0x121a9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S5_PS_ZX_ADAPT_CTL"
      sgroup "S5_PS_ZX_ADAPT_CTL (at 0x121aa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S5_PS_ZX_ADAPT_VAL"
      sgroup "S5_PS_ZX_ADAPT_VAL (at 0x121ab)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S5_PS_ADC_CLK_CTL"
      sgroup "S5_PS_ADC_CLK_CTL (at 0x121ac)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_PULSE_SKIP_CLK_EN                    = " "0 (ADC_PULS_SKIP_CLK_DISABL),1 (ADC_PULS_SKIP_CLK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S5_PS_ATEST12"
      sgroup "S5_PS_ATEST12 (at 0x121b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S5_PS_ATEST34"
      sgroup "S5_PS_ATEST34 (at 0x121b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S5_PS_DTEST12"
      sgroup "S5_PS_DTEST12 (at 0x121b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_DTEST_ADC_2),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_DTEST_ADC_1),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S5_PS_DTEST43"
      sgroup "S5_PS_DTEST43 (at 0x121b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_DTEST_ADC_3),2 (DTEST3_DTEST_ADC_4),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S5_PS_GANG_CTL1"
      sgroup "S5_PS_GANG_CTL1 (at 0x121c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_PS_GANG_CTL2"
      sgroup "S5_PS_GANG_CTL2 (at 0x121c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      sgroup "S5_PS_SEC_ACCESS (at 0x121d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      sgroup "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      sgroup "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      sgroup "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_PS_CAL_REQUEST"
      sgroup "S5_PS_CAL_REQUEST (at 0x121e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S5_PS_MAN_CAL_VAL"
      sgroup "S5_PS_MAN_CAL_VAL (at 0x121e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S5_PS_REPLICA_CFG"
      sgroup "S5_PS_REPLICA_CFG (at 0x121e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S5_PS_CAL_CTL_1"
      sgroup "S5_PS_CAL_CTL_1 (at 0x121e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_USE_SAMPLE_OFFSET_TRIM),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_USE_ZX_TRIM_2),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S5_PS_CAL_CTL_2"
      sgroup "S5_PS_CAL_CTL_2 (at 0x121e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SAMPLE_OFFSET_CAL_EN                     = " "0 (SAMPL_OFFSET_CAL_MISSON_MODE),1 (SAMPL_OFFSET_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S5_PS_SAMPLE_OFFSET_CAL_VAL"
      sgroup "S5_PS_SAMPLE_OFFSET_CAL_VAL (at 0x121e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_CAL_VAL                    = "
    tree.end
    tree "S5_PS_REPLICA_CAL_VAL"
      sgroup "S5_PS_REPLICA_CAL_VAL (at 0x121ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S5_PS_DACMID_BUF_CAL_VAL"
      sgroup "S5_PS_DACMID_BUF_CAL_VAL (at 0x121ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S5_PS_FRONT_BUF_CAL_VAL"
      sgroup "S5_PS_FRONT_BUF_CAL_VAL (at 0x121ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S5_PS_CL_CAL_VAL"
      sgroup "S5_PS_CL_CAL_VAL (at 0x121ee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S5_PS_ZX_CAL_VAL"
      sgroup "S5_PS_ZX_CAL_VAL (at 0x121ef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S5_PS_TRIM_NUM"
      sgroup "S5_PS_TRIM_NUM (at 0x121f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_PS_ZX_TRIM"
      sgroup "S5_PS_ZX_TRIM (at 0x121f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S5_PS_CL_TRIM"
      sgroup "S5_PS_CL_TRIM (at 0x121f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S5_PS_REPLICA_TRIM"
      sgroup "S5_PS_REPLICA_TRIM (at 0x121f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
    tree "S5_PS_SAMPLE_OFFSET_TRIM"
      sgroup "S5_PS_SAMPLE_OFFSET_TRIM (at 0x121f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SAMPLE_OFFSET_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      sgroup "TEMP_ALARM_TEST1 (at 0x24e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      sgroup "TEMP_ALARM_TEST2 (at 0x24e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      sgroup "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end

